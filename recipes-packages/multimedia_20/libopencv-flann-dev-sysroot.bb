inherit deb-dl

LICENSE = "BSD-3-Clause & MIT & BSD-2-clause"

FULL_LINK = 'http://ports.ubuntu.com/ubuntu-ports/pool/universe/o/opencv/libopencv-flann-dev_4.2.0+dfsg-5_arm64.deb'

DEB_NAME = 'libopencv-flann-dev_4.2.0+dfsg-5_arm64.deb'

SRC_URI[md5sum] = "58c24f3b9878255744b1c329c98450ae"
