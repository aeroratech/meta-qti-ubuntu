inherit deb-dl

LICENSE = "LGPL-2.0+ & MIT & BSD"

FULL_LINK = 'http://ports.ubuntu.com/ubuntu-ports/pool/main/g/gst-plugins-good1.0/libgstreamer-plugins-good1.0-0_1.16.2-1ubuntu2_arm64.deb'

DEB_NAME = 'libgstreamer-plugins-good1.0-0_1.16.2-1ubuntu2_arm64.deb'

SRC_URI[md5sum] = "52807278f59cf38f5501e43f8f465bad"
