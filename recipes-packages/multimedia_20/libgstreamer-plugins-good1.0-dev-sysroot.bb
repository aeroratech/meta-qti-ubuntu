inherit deb-dl

LICENSE = "LGPL-2.0+ & LGPL-2.1+ & MIT & GPL-2.0+ & BSD"

FULL_LINK = 'http://ports.ubuntu.com/ubuntu-ports/pool/main/g/gst-plugins-good1.0/libgstreamer-plugins-good1.0-dev_1.16.2-1ubuntu2_arm64.deb'

DEB_NAME = 'libgstreamer-plugins-good1.0-dev_1.16.2-1ubuntu2_arm64.deb'

SRC_URI[md5sum] = "e719899269a179785a0687570c049e8c"
