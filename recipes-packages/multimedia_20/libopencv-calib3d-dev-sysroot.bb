inherit deb-dl

LICENSE = "BSD-3-Clause & MIT & BSD-2-clause"

FULL_LINK = 'http://ports.ubuntu.com/ubuntu-ports/pool/universe/o/opencv/libopencv-calib3d-dev_4.2.0+dfsg-5_arm64.deb'

DEB_NAME = 'libopencv-calib3d-dev_4.2.0+dfsg-5_arm64.deb'

SRC_URI[md5sum] = "7e3c260379e69e3c1012b95661525408"
