inherit deb-dl

LICENSE = "BSD-3-Clause & MIT & BSD-2-clause"

FULL_LINK = 'http://ports.ubuntu.com/ubuntu-ports/pool/universe/o/opencv/libopencv-core4.2_4.2.0+dfsg-5_arm64.deb'

DEB_NAME = 'libopencv-core4.2_4.2.0+dfsg-5_arm64.deb'

SRC_URI[md5sum] = "0c5f7abbd61c8101042b733c75e06055"
