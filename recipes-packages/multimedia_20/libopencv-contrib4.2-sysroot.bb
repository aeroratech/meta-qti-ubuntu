inherit deb-dl

LICENSE = "BSD-3-Clause & MIT & BSD-2-clause"

FULL_LINK = 'http://ports.ubuntu.com/ubuntu-ports/pool/universe/o/opencv/libopencv-contrib4.2_4.2.0+dfsg-5_arm64.deb'

DEB_NAME = 'libopencv-contrib4.2_4.2.0+dfsg-5_arm64.deb'

SRC_URI[md5sum] = "1e43699678527e7aa0a489053d1a5b3a"
