inherit deb-dl

LICENSE = "LGPL-2.0+ & GPL-2.0+ & GPL-3.0+"

FULL_LINK = 'http://ports.ubuntu.com/ubuntu-ports/pool/main/g/gstreamer1.0/libgstreamer1.0-0_1.16.2-2_arm64.deb'

DEB_NAME = 'libgstreamer1.0-0_1.16.2-2_arm64.deb'

SRC_URI[md5sum] = "35b6db3329422082c41f91981d9294b6"
