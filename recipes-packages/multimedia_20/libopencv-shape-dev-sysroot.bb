inherit deb-dl

LICENSE = "BSD-3-Clause & MIT & BSD-2-clause"

FULL_LINK = 'http://ports.ubuntu.com/ubuntu-ports/pool/universe/o/opencv/libopencv-shape-dev_4.2.0+dfsg-5_arm64.deb'

DEB_NAME = 'libopencv-shape-dev_4.2.0+dfsg-5_arm64.deb'

SRC_URI[md5sum] = "a704c36e2e30ffdc7979b236b1810040"
