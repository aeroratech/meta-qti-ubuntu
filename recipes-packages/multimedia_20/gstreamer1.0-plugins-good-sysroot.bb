inherit deb-dl

LICENSE = "LGPL-2.0+ & LGPL-2.1+ & GPL-2.0+ & MIT"

FULL_LINK = 'http://ports.ubuntu.com/ubuntu-ports/pool/main/g/gst-plugins-good1.0/gstreamer1.0-plugins-good_1.16.2-1ubuntu2_arm64.deb'

DEB_NAME = 'gstreamer1.0-plugins-good_1.16.2-1ubuntu2_arm64.deb'

SRC_URI[md5sum] = "c45edd1448e396b0a20d5a3ef19b1cdf"
