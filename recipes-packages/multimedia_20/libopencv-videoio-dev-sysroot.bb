inherit deb-dl

LICENSE = "BSD-3-Clause & MIT & BSD-2-clause"

FULL_LINK = 'http://ports.ubuntu.com/ubuntu-ports/pool/universe/o/opencv/libopencv-videoio-dev_4.2.0+dfsg-5_arm64.deb'

DEB_NAME = 'libopencv-videoio-dev_4.2.0+dfsg-5_arm64.deb'

SRC_URI[md5sum] = "fc096f2f149b196526768152d166c2fa"
