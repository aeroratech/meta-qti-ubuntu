inherit deb-dl

LICENSE = "MIT"

FULL_LINK = 'http://ports.ubuntu.com/ubuntu-ports/pool/main/b/brotli/libbrotli-dev_1.0.7-6build1_arm64.deb'

DEB_NAME = 'libbrotli-dev_1.0.7-6build1_arm64.deb'

SRC_URI[md5sum] = "4d31e324eeef221a43331e9cef39af24"
