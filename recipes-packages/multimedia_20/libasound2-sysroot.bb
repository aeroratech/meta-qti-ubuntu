inherit deb-dl

LICENSE = "LGPL-2.0+"

FULL_LINK = 'http://ports.ubuntu.com/ubuntu-ports/pool/main/a/alsa-lib/libasound2_1.2.2-2.1_arm64.deb'

DEB_NAME = 'libasound2_1.2.2-2.1_arm64.deb'

SRC_URI[md5sum] = "fbefc5f478d87b3b153287c88bdb6d84"
