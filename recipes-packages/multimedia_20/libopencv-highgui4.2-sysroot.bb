inherit deb-dl

LICENSE = "BSD-3-Clause & MIT & BSD-2-clause"

FULL_LINK = 'http://ports.ubuntu.com/ubuntu-ports/pool/universe/o/opencv/libopencv-highgui4.2_4.2.0+dfsg-5_arm64.deb'

DEB_NAME = 'libopencv-highgui4.2_4.2.0+dfsg-5_arm64.deb'

SRC_URI[md5sum] = "f5694fc63f528ed12604ea754a6102c4"
