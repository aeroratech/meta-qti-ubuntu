inherit deb-dl

LICENSE = "LGPL-2.0+"

FULL_LINK = 'http://ports.ubuntu.com/ubuntu-ports/pool/main/a/alsa-lib/libasound2-dev_1.2.2-2.1_arm64.deb'

DEB_NAME = 'libasound2-dev_1.2.2-2.1_arm64.deb'

SRC_URI[md5sum] = "93e15d9a03b31eadc711c30d380b85ef"
