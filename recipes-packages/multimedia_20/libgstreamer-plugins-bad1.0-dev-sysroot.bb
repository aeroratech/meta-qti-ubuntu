inherit deb-dl

LICENSE = "LGPL-2.0+ & MIT & BSD & GPL-2.0+ & MPL-1.1 & GPL-3.0+ & LGPL-2.1+"

FULL_LINK = 'http://ports.ubuntu.com/ubuntu-ports/pool/universe/g/gst-plugins-bad1.0/libgstreamer-plugins-bad1.0-dev_1.16.2-2.1ubuntu1_arm64.deb'

DEB_NAME = 'libgstreamer-plugins-bad1.0-dev_1.16.2-2.1ubuntu1_arm64.deb'

SRC_URI[md5sum] = "9277d196584b52b453f216db366d8b1b"
