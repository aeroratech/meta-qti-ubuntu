inherit deb-dl

LICENSE = "BSD-3-Clause & MIT & BSD-2-clause"

FULL_LINK = 'http://ports.ubuntu.com/ubuntu-ports/pool/universe/o/opencv/libopencv-photo-dev_4.2.0+dfsg-5_arm64.deb'

DEB_NAME = 'libopencv-photo-dev_4.2.0+dfsg-5_arm64.deb'

SRC_URI[md5sum] = "04ee61dda092634dc8b8a8a597583eaf"
