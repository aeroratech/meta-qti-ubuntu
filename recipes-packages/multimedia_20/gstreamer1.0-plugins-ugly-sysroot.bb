inherit deb-dl

LICENSE = "LGPL-2.0+ & GPL-2.0+"

FULL_LINK = 'http://ports.ubuntu.com/ubuntu-ports/pool/universe/g/gst-plugins-ugly1.0/gstreamer1.0-plugins-ugly_1.16.2-2build1_arm64.deb'

DEB_NAME = 'gstreamer1.0-plugins-ugly_1.16.2-2build1_arm64.deb'

SRC_URI[md5sum] = "02a4ea019bd8ce82acee00a314803257"
