inherit deb-dl

LICENSE = "MIT & BSD-3-Clause"

FULL_LINK = 'http://ports.ubuntu.com/ubuntu-ports/pool/main/libp/libpsl/libpsl5_0.21.0-1ubuntu1_arm64.deb'

DEB_NAME = 'libpsl5_0.21.0-1ubuntu1_arm64.deb'

SRC_URI[md5sum] = "4071d38db6a0cfe3465522cb95473e1c"
