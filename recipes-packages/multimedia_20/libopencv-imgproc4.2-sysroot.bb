inherit deb-dl

LICENSE = "BSD-3-Clause & MIT & BSD-2-clause"

FULL_LINK = 'http://ports.ubuntu.com/ubuntu-ports/pool/universe/o/opencv/libopencv-imgproc4.2_4.2.0+dfsg-5_arm64.deb'

DEB_NAME = 'libopencv-imgproc4.2_4.2.0+dfsg-5_arm64.deb'

SRC_URI[md5sum] = "a03f9457c6fc6e80e8e1e524662ac687"
