inherit deb-dl

LICENSE = "MIT & BSD-3-Clause"

FULL_LINK = 'http://ports.ubuntu.com/ubuntu-ports/pool/main/libp/libpsl/libpsl-dev_0.21.0-1ubuntu1_arm64.deb'

DEB_NAME = 'libpsl-dev_0.21.0-1ubuntu1_arm64.deb'

SRC_URI[md5sum] = "46618901857bd69c654623c6c31fa1f6"
