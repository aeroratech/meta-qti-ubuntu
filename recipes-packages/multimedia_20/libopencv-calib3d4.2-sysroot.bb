inherit deb-dl

LICENSE = "BSD-3-Clause & MIT & BSD-2-clause"

FULL_LINK = 'http://ports.ubuntu.com/ubuntu-ports/pool/universe/o/opencv/libopencv-calib3d4.2_4.2.0+dfsg-5_arm64.deb'

DEB_NAME = 'libopencv-calib3d4.2_4.2.0+dfsg-5_arm64.deb'

SRC_URI[md5sum] = "f36351bc983e38182293785d775ac500"
