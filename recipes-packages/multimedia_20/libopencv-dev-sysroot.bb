inherit deb-dl

LICENSE = "BSD-3-Clause & MIT & BSD-2-clause"

FULL_LINK = 'http://ports.ubuntu.com/ubuntu-ports/pool/universe/o/opencv/libopencv-dev_4.2.0+dfsg-5_arm64.deb'

DEB_NAME = 'libopencv-dev_4.2.0+dfsg-5_arm64.deb'

SRC_URI[md5sum] = "4be05ba57a96c607ce87229fefc2c73c"
