inherit deb-dl

LICENSE = "BSD-3-Clause & MIT & BSD-2-clause"

FULL_LINK = 'http://ports.ubuntu.com/ubuntu-ports/pool/universe/o/opencv/libopencv-imgcodecs4.2_4.2.0+dfsg-5_arm64.deb'

DEB_NAME = 'libopencv-imgcodecs4.2_4.2.0+dfsg-5_arm64.deb'

SRC_URI[md5sum] = "0507f7c71562cbf6b96a413260462dd8"
