inherit deb-dl

LICENSE = "LGPL-2.0+ & BSD-2-clause & MIT"

FULL_LINK = 'http://ports.ubuntu.com/ubuntu-ports/pool/main/g/gst-plugins-base1.0/gstreamer1.0-gl_1.16.2-4_arm64.deb'

DEB_NAME = 'gstreamer1.0-gl_1.16.2-4_arm64.deb'

SRC_URI[md5sum] = "395337baaa4bf7cfae5d2214aacd0c57"
