inherit deb-dl

LICENSE = "BSD-3-Clause & MIT & BSD-2-clause"

FULL_LINK = 'http://ports.ubuntu.com/ubuntu-ports/pool/universe/o/opencv/libopencv-dnn-dev_4.2.0+dfsg-5_arm64.deb'

DEB_NAME = 'libopencv-dnn-dev_4.2.0+dfsg-5_arm64.deb'

SRC_URI[md5sum] = "c5cf62b4bc5e5c7cde7537e62eb75b94"
