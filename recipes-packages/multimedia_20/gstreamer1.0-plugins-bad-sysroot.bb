inherit deb-dl

LICENSE = "LGPL-2.0+ & GPL-2.0+ &MIT & MPL-1.1 & GPL-3.0+"

FULL_LINK = 'http://ports.ubuntu.com/ubuntu-ports/pool/universe/g/gst-plugins-bad1.0/gstreamer1.0-plugins-bad_1.16.2-2.1ubuntu1_arm64.deb'

DEB_NAME = 'gstreamer1.0-plugins-bad_1.16.2-2.1ubuntu1_arm64.deb'

SRC_URI[md5sum] = "db9c8b0125a3aeaf95a13e650e154d4d"
