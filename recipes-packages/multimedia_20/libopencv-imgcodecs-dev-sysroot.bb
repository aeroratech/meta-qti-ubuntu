inherit deb-dl

LICENSE = "BSD-3-Clause & MIT & BSD-2-clause"

FULL_LINK = 'http://ports.ubuntu.com/ubuntu-ports/pool/universe/o/opencv/libopencv-imgcodecs-dev_4.2.0+dfsg-5_arm64.deb'

DEB_NAME = 'libopencv-imgcodecs-dev_4.2.0+dfsg-5_arm64.deb'

SRC_URI[md5sum] = "be54a16a64b39f31a759d9c15b20c8f5"
