inherit deb-dl

LICENSE = "BSD-3-Clause & MIT & BSD-2-clause"

FULL_LINK = 'http://ports.ubuntu.com/ubuntu-ports/pool/universe/o/opencv/libopencv-video-dev_4.2.0+dfsg-5_arm64.deb'

DEB_NAME = 'libopencv-video-dev_4.2.0+dfsg-5_arm64.deb'

SRC_URI[md5sum] = "084436c90495cad8608df6eb2f3ae38d"
