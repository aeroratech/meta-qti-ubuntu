inherit deb-dl

LICENSE = "GPL-2.0+"

FULL_LINK = 'http://ports.ubuntu.com/ubuntu-ports/pool/main/s/shared-mime-info/shared-mime-info_1.15-1_arm64.deb'

DEB_NAME = 'shared-mime-info_1.15-1_arm64.deb'

SRC_URI[md5sum] = "b1b3d745c195cb4dd3f9ccc27a8c56fe"
