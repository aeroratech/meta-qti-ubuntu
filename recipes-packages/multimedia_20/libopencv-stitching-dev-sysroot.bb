inherit deb-dl

LICENSE = "BSD-3-Clause & MIT & BSD-2-clause"

FULL_LINK = 'http://ports.ubuntu.com/ubuntu-ports/pool/universe/o/opencv/libopencv-stitching-dev_4.2.0+dfsg-5_arm64.deb'

DEB_NAME = 'libopencv-stitching-dev_4.2.0+dfsg-5_arm64.deb'

SRC_URI[md5sum] = "8bdb94ac811cd68279f8e6ea930ad4af"
