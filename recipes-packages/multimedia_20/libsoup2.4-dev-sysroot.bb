inherit deb-dl

LICENSE = "LGPL-2.0+ & MIT"

FULL_LINK = 'http://ports.ubuntu.com/ubuntu-ports/pool/main/libs/libsoup2.4/libsoup2.4-dev_2.70.0-1_arm64.deb'

DEB_NAME = 'libsoup2.4-dev_2.70.0-1_arm64.deb'

SRC_URI[md5sum] = "d398bde6898799e9265cb8a1968b6b6e"
