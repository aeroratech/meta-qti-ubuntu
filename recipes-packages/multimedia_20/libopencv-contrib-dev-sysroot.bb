inherit deb-dl

LICENSE = "BSD-3-Clause & MIT & BSD-2-clause"

FULL_LINK = 'http://ports.ubuntu.com/ubuntu-ports/pool/universe/o/opencv/libopencv-contrib-dev_4.2.0+dfsg-5_arm64.deb'

DEB_NAME = 'libopencv-contrib-dev_4.2.0+dfsg-5_arm64.deb'

SRC_URI[md5sum] = "c43ba48b910020530a7a8cc918228981"
