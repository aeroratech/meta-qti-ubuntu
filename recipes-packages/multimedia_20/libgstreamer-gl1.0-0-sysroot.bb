inherit deb-dl

LICENSE = "LGPL-2.0+ & MIT & BSD"

FULL_LINK = 'http://ports.ubuntu.com/ubuntu-ports/pool/main/g/gst-plugins-base1.0/libgstreamer-gl1.0-0_1.16.2-4_arm64.deb'

DEB_NAME = 'libgstreamer-gl1.0-0_1.16.2-4_arm64.deb'

SRC_URI[md5sum] = "903d29116e5de74a967dad79599f68f0"
