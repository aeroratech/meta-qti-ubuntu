inherit deb-dl

LICENSE = "LGPL-2.0+ & BSD-2-clause & BSD-3-Clause & MIT"

FULL_LINK = 'http://ports.ubuntu.com/ubuntu-ports/pool/main/g/gst-plugins-base1.0/gstreamer1.0-plugins-base_1.16.2-4_arm64.deb'

DEB_NAME = 'gstreamer1.0-plugins-base_1.16.2-4_arm64.deb'

SRC_URI[md5sum] = "33bd21920eb5aeb484afc0f5b29f26b8"
