inherit deb-dl

LICENSE = "LGPL-2.0+ & MIT & MPL-1.1 & GPL-2.0+ & BSD"

FULL_LINK = 'http://ports.ubuntu.com/ubuntu-ports/pool/universe/g/gst-plugins-bad1.0/libgstreamer-plugins-bad1.0-0_1.16.2-2.1ubuntu1_arm64.deb'

DEB_NAME = 'libgstreamer-plugins-bad1.0-0_1.16.2-2.1ubuntu1_arm64.deb'

SRC_URI[md5sum] = "a16d4afe528f4ba9088bff772a14bfeb"
