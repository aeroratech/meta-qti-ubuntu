inherit deb-dl

LICENSE = "BSD-3-Clause & MIT & BSD-2-clause"

FULL_LINK = 'http://ports.ubuntu.com/ubuntu-ports/pool/universe/o/opencv/libopencv-core-dev_4.2.0+dfsg-5_arm64.deb'

DEB_NAME = 'libopencv-core-dev_4.2.0+dfsg-5_arm64.deb'

SRC_URI[md5sum] = "d52050959225609ed94792751fb715e3"
