inherit deb-dl

LICENSE = "MIT"

FULL_LINK = 'http://ports.ubuntu.com/ubuntu-ports/pool/main/b/brotli/libbrotli1_1.0.7-6build1_arm64.deb'

DEB_NAME = 'libbrotli1_1.0.7-6build1_arm64.deb'

SRC_URI[md5sum] = "e81c40f3ce55f8a97d1e3a92954eb2cb"
