inherit deb-dl

LICENSE = "LGPL-2.0+ & GPL-2.0+ & MIT"

FULL_LINK = 'http://ports.ubuntu.com/ubuntu-ports/pool/main/g/gst-plugins-base1.0/libgstreamer-plugins-base1.0-0_1.16.2-4_arm64.deb'

DEB_NAME = 'libgstreamer-plugins-base1.0-0_1.16.2-4_arm64.deb'

SRC_URI[md5sum] = "534e65575545c722951d6929ed5be09f"
