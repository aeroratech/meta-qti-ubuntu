inherit deb-dl

LICENSE = "GPL-2.0 & LGPL-2.0+"

FULL_LINK = 'http://ports.ubuntu.com/ubuntu-ports/pool/main/a/alsa-utils/alsa-utils_1.2.2-1ubuntu1_arm64.deb'

DEB_NAME = 'alsa-utils_1.2.2-1ubuntu1_arm64.deb'

SRC_URI[md5sum] = "5daedeb56e51bf8bf515c85afc7aee5e"
