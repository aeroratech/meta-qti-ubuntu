inherit deb-dl

LICENSE = "LGPL-2.0+"

FULL_LINK = 'http://ports.ubuntu.com/ubuntu-ports/pool/universe/g/gst-rtsp-server1.0/libgstrtspserver-1.0-0_1.16.2-3_arm64.deb'

DEB_NAME = 'libgstrtspserver-1.0-0_1.16.2-3_arm64.deb'

SRC_URI[md5sum] = "8affd1ea1a6e799c43e992138be183fa"
