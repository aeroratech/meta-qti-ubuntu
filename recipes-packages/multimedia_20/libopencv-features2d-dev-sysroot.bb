inherit deb-dl

LICENSE = "BSD-3-Clause & MIT & BSD-2-clause"

FULL_LINK = 'http://ports.ubuntu.com/ubuntu-ports/pool/universe/o/opencv/libopencv-features2d-dev_4.2.0+dfsg-5_arm64.deb'

DEB_NAME = 'libopencv-features2d-dev_4.2.0+dfsg-5_arm64.deb'

SRC_URI[md5sum] = "e25aa7aecf6a80a6e8c960f0c99dd506"
