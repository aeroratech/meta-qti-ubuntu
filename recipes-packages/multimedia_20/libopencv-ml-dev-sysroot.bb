inherit deb-dl

LICENSE = "BSD-3-Clause & MIT & BSD-2-clause"

FULL_LINK = 'http://ports.ubuntu.com/ubuntu-ports/pool/universe/o/opencv/libopencv-ml-dev_4.2.0+dfsg-5_arm64.deb'

DEB_NAME = 'libopencv-ml-dev_4.2.0+dfsg-5_arm64.deb'

SRC_URI[md5sum] = "f470030c6a6a60a0c0f345557d28e5ef"
