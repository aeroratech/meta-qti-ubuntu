inherit deb-dl

LICENSE = "BSD-3-Clause & MIT & BSD-2-clause"

FULL_LINK = 'http://ports.ubuntu.com/ubuntu-ports/pool/universe/o/opencv/libopencv-videostab-dev_4.2.0+dfsg-5_arm64.deb'

DEB_NAME = 'libopencv-videostab-dev_4.2.0+dfsg-5_arm64.deb'

SRC_URI[md5sum] = "1962def494a36bbcb743e6c3805ee10a"
