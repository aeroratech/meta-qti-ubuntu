inherit deb-dl

LICENSE = "BSD-3-Clause & MIT & BSD-2-clause"

FULL_LINK = 'http://ports.ubuntu.com/ubuntu-ports/pool/universe/o/opencv/libopencv-features2d4.2_4.2.0+dfsg-5_arm64.deb'

DEB_NAME = 'libopencv-features2d4.2_4.2.0+dfsg-5_arm64.deb'

SRC_URI[md5sum] = "0430a0f0a4004ec75302dff9b7b68b3d"
