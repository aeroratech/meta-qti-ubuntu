inherit deb-dl

LICENSE = "BSD-3-Clause & MIT & BSD-2-clause"

FULL_LINK = 'http://ports.ubuntu.com/ubuntu-ports/pool/universe/o/opencv/libopencv4.2-java_4.2.0+dfsg-5_all.deb'

DEB_NAME = 'libopencv4.2-java_4.2.0+dfsg-5_all.deb'

SRC_URI[md5sum] = "f3072fb2d324957295d264c3aec0de8f"
