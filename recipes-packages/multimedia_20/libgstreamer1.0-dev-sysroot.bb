inherit deb-dl

LICENSE = "LGPL-2.0+ & LGPL-2.1+ & GPL-2.0+ & GPL-3.0+"

FULL_LINK = 'http://ports.ubuntu.com/ubuntu-ports/pool/main/g/gstreamer1.0/libgstreamer1.0-dev_1.16.2-2_arm64.deb'

DEB_NAME = 'libgstreamer1.0-dev_1.16.2-2_arm64.deb'

SRC_URI[md5sum] = "7e692e6cc6b47e199a58884b63b5a3b9"
