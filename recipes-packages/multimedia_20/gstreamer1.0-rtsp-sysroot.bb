inherit deb-dl

LICENSE = "LGPL-2.0+"

FULL_LINK = 'http://ports.ubuntu.com/ubuntu-ports/pool/universe/g/gst-rtsp-server1.0/gstreamer1.0-rtsp_1.16.2-3_arm64.deb'

DEB_NAME = 'gstreamer1.0-rtsp_1.16.2-3_arm64.deb'

SRC_URI[md5sum] = "fe5c878f28c46486efc4748b57b4e50b"
