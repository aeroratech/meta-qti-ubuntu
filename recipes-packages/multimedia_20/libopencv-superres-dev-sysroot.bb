inherit deb-dl

LICENSE = "BSD-3-Clause & MIT & BSD-2-clause"

FULL_LINK = 'http://ports.ubuntu.com/ubuntu-ports/pool/universe/o/opencv/libopencv-superres-dev_4.2.0+dfsg-5_arm64.deb'

DEB_NAME = 'libopencv-superres-dev_4.2.0+dfsg-5_arm64.deb'

SRC_URI[md5sum] = "764a204b89b5f49bdcac7f2b3274aeda"
