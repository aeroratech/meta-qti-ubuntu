inherit deb-dl

LICENSE = "BSD-3-Clause & MIT & BSD-2-clause"

FULL_LINK = 'http://ports.ubuntu.com/ubuntu-ports/pool/universe/o/opencv/libopencv-ts-dev_4.2.0+dfsg-5_arm64.deb'

DEB_NAME = 'libopencv-ts-dev_4.2.0+dfsg-5_arm64.deb'

SRC_URI[md5sum] = "47bd1d1b5cbaebcb190b13ad213477c6"
