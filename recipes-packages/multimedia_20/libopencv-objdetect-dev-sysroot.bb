inherit deb-dl

LICENSE = "BSD-3-Clause & MIT & BSD-2-clause"

FULL_LINK = 'http://ports.ubuntu.com/ubuntu-ports/pool/universe/o/opencv/libopencv-objdetect-dev_4.2.0+dfsg-5_arm64.deb'

DEB_NAME = 'libopencv-objdetect-dev_4.2.0+dfsg-5_arm64.deb'

SRC_URI[md5sum] = "340c1212b6ddc692b861a76d844fc2b3"
