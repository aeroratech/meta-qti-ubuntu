inherit native deb-dl

LICENSE = "LGPL-2.1"

FULL_LINK = 'http://security.ubuntu.com/ubuntu/pool/main/l/linux/linux-libc-dev_4.15.0-74.84_amd64.deb'
DEB_NAME = 'linux-libc-dev_4.15.0-74.84_amd64.deb'
SRC_URI[md5sum] = "f031d990be3dc4bdbacf6c7fc8979c67"
