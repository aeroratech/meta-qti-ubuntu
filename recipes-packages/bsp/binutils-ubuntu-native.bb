inherit native deb-dl

LICENSE = "GPL-3.0+"

SRC_URI[md5sum] = "964a06908c6bf73e128c1a55e8cb2c1f"

FULL_LINK = 'http://security.ubuntu.com/ubuntu/pool/main/b/binutils/binutils-aarch64-linux-gnu_2.30-21ubuntu1~18.04.2_amd64.deb'
DEB_NAME = 'binutils-aarch64-linux-gnu_2.30-21ubuntu1~18.04.2_amd64.deb'
