inherit native deb-dl

LICENSE = "MIT & LGPL-2.1+ & BSD-2-Clause"

FULL_LINK = 'http://kr.archive.ubuntu.com/ubuntu/pool/main/i/isl/libisl19_0.19-1_amd64.deb'
DEB_NAME = 'libisl19_0.19-1_amd64.deb'
SRC_URI[md5sum] = "27d5d5ed547d29270196f8c7f19c669d"
