inherit native deb-dl

LICENSE = "LGPL-2.1"

FULL_LINK = 'http://security.ubuntu.com/ubuntu/pool/main/libn/libnl3/libnl-3-200_3.2.29-0ubuntu3_amd64.deb'
DEB_NAME = 'libnl-3-200_3.2.29-0ubuntu3_amd64.deb'
SRC_URI[md5sum] = "e3442642ca58b1efa9524b71c40e3fae"
