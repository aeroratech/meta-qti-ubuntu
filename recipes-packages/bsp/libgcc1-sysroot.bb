inherit native deb-dl

LICENSE = "GPL-3.0-with-GCC-exception & GPLv3"

FULL_LINK = 'http://security.ubuntu.com/ubuntu/pool/main/g/gcc-8/libgcc1_8.3.0-6ubuntu1~18.04.1_amd64.deb'
DEB_NAME = 'libgcc1_8.3.0-6ubuntu1~18.04.1_amd64.deb'
SRC_URI[md5sum] = "942fb35f484c8cbee9a011d2f304124a"
