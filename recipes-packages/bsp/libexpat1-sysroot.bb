inherit native deb-dl

LICENSE = "MIT"

FULL_LINK = 'http://security.ubuntu.com/ubuntu/pool/main/e/expat/libexpat1_2.2.5-3ubuntu0.2_amd64.deb'
DEB_NAME = 'libexpat1_2.2.5-3ubuntu0.2_amd64.deb'

SRC_URI[md5sum] = "77a5c6f398e5f0b1528f5f86dba3e70a"
