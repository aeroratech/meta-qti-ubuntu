inherit native deb-dl

LICENSE = "EPL-1.0"

SRC_URI[md5sum] = "96ff34911ce2643146e94f65f327658f"

FULL_LINK = 'http://security.ubuntu.com/ubuntu/pool/main/g/gcc-7-cross/g++-7-aarch64-linux-gnu_7.4.0-1ubuntu1~18.04.1cross1_amd64.deb'
DEB_NAME = 'g++-7-aarch64-linux-gnu_7.4.0-1ubuntu1~18.04.1cross1_amd64.deb'
