inherit native deb-dl

LICENSE = "BSD & MIT & PD"

FULL_LINK = 'http://security.ubuntu.com/ubuntu/pool/main/f/file/libmagic1_5.32-2ubuntu0.3_amd64.deb'
DEB_NAME = 'libmagic1_5.32-2ubuntu0.3_amd64.deb'
SRC_URI[md5sum] = "3001c1c37a277d7cf369b3b37d5a0768"
