inherit native deb-dl

LICENSE = "GPLv2+ & LGPLv2.1+ & BSD-3-Clause & BSD-4-Clause & MIT & PD & GPLv3"

FULL_LINK = 'http://security.ubuntu.com/ubuntu/pool/main/u/util-linux/libmount1_2.31.1-0.4ubuntu3_amd64.deb'
DEB_NAME = 'libmount1_2.31.1-0.4ubuntu3_amd64.deb'
SRC_URI[md5sum] = "398f07b1f369d6766883e76b7d492f96"
