inherit native deb-dl

LICENSE = "GFDL-1.2 & LGPL-3.0+"

FULL_LINK = 'http://security.ubuntu.com/ubuntu/pool/main/m/mpfr4/libmpfr6_4.0.1-1_amd64.deb'
DEB_NAME = 'libmpfr6_4.0.1-1_amd64.deb'
SRC_URI[md5sum] = "6be5dbed25124c8174c8aa13932d8206"
