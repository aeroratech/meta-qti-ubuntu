inherit native deb-dl

LICENSE = " GPL-3.0-with-GCC-exception & GPLv3"

SRC_URI[md5sum] = "745b2592a3bbfc2e05d03f2d4322d40b"

FULL_LINK = 'http://security.ubuntu.com/ubuntu/pool/main/g/gcc-7/cpp-7_7.5.0-3ubuntu1~18.04_amd64.deb'
DEB_NAME = 'cpp-7_7.5.0-3ubuntu1~18.04_amd64.deb'
