inherit native deb-dl

LICENSE = "GPL-3.0-with-GCC-exception & GPLv3"

FULL_LINK = 'http://security.ubuntu.com/ubuntu/pool/main/g/gcc-7/libstdc++-7-dev_7.4.0-1ubuntu1~18.04.1_amd64.deb'
DEB_NAME = 'libstdc++-7-dev_7.4.0-1ubuntu1~18.04.1_amd64.deb'
SRC_URI[md5sum] = "2d985d5813ca92085585bc342a744106"
