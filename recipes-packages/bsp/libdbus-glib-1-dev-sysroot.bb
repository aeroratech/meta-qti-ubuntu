inherit deb-dl

LICENSE = "GPL-2.0+ | AFL-2.1"

FULL_LINK = 'http://ports.ubuntu.com/ubuntu-ports/pool/main/d/dbus-glib/libdbus-glib-1-dev_0.110-2_arm64.deb'
DEB_NAME = 'libdbus-glib-1-dev_0.110-2_arm64.deb'

SRC_URI[md5sum] = "8485b6a734845fde276dc3e6f3ddba68"
