inherit native deb-dl

LICENSE = "GPL-2.0+ & BSD-4-Clause"

SRC_URI[md5sum] = "300630d94d4b06c7c3805b0b3674730d"

FULL_LINK = 'http://security.ubuntu.com/ubuntu/pool/main/g/gcc-defaults/gcc-aarch64-linux-gnu_7.4.0-1ubuntu2.3_amd64.deb'
DEB_NAME = 'gcc-aarch64-linux-gnu_7.4.0-1ubuntu2.3_amd64.deb'
