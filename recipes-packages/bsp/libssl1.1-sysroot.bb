inherit native deb-dl

LICENSE = "OpenSSL"

FULL_LINK = 'http://security.ubuntu.com/ubuntu/pool/main/o/openssl/libssl1.1_1.1.1-1ubuntu2.1~18.04.5_amd64.deb'
DEB_NAME = 'libssl1.1_1.1.1-1ubuntu2.1~18.04.5_amd64.deb'
SRC_URI[md5sum] = "dd90fcffe8c67128a0d5bc29af2b2395"
