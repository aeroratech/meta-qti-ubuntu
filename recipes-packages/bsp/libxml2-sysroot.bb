inherit deb-dl

LICENSE = "MIT"

SRC_URI[md5sum] = "23ba86379575be3a59c7c68c5b06bb86"

FULL_LINK = 'http://ports.ubuntu.com/ubuntu-ports/pool/main/libx/libxml2/libxml2_2.9.4+dfsg1-6.1ubuntu1.4_arm64.deb'
DEB_NAME = 'libxml2_2.9.4+dfsg1-6.1ubuntu1.4_arm64.deb'
