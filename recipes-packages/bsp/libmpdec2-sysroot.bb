inherit native deb-dl

LICENSE = "BSD & GPL-2.0+"

FULL_LINK = 'http://security.ubuntu.com/ubuntu/pool/main/m/mpdecimal/libmpdec2_2.4.2-1ubuntu1_amd64.deb'
DEB_NAME = 'libmpdec2_2.4.2-1ubuntu1_amd64.deb'
SRC_URI[md5sum] = "cf77a5b33510c68c9bae9d8e505f2d46"
