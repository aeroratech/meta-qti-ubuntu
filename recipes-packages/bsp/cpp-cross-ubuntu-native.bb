inherit native deb-dl

LICENSE = "EPL-1.0"

SRC_URI[md5sum] = "c5a20c75b39b41654f70c3d1c312a7be"

FULL_LINK = 'http://security.ubuntu.com/ubuntu/pool/main/g/gcc-7-cross/cpp-7-aarch64-linux-gnu_7.4.0-1ubuntu1~18.04.1cross1_amd64.deb'
DEB_NAME = 'cpp-7-aarch64-linux-gnu_7.4.0-1ubuntu1~18.04.1cross1_amd64.deb'
