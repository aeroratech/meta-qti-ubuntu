inherit native deb-dl

LICENSE = "EPL-1.0"

FULL_LINK = 'http://security.ubuntu.com/ubuntu/pool/main/g/gcc-7-cross/libstdc++-7-dev-arm64-cross_7.4.0-1ubuntu1~18.04.1cross1_all.deb'
DEB_NAME = 'libstdc++-7-dev-arm64-cross_7.4.0-1ubuntu1~18.04.1cross1_all.deb'
SRC_URI[md5sum] = "89b59547dbb7b06867f56efbf9a78c1b"
