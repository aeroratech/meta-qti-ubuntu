inherit native deb-dl

LICENSE = "GPL-3.0-with-GCC-exception & GPLv3"

SRC_URI[md5sum] = "f30d7be636a20b5b4e55636847641509"

FULL_LINK = 'http://security.ubuntu.com/ubuntu/pool/main/g/gcc-7/gcc-7_7.5.0-3ubuntu1~18.04_amd64.deb'
DEB_NAME = 'gcc-7_7.5.0-3ubuntu1~18.04_amd64.deb'
