inherit native deb-dl

LICENSE = "EPL-1.0"

FULL_LINK = 'http://security.ubuntu.com/ubuntu/pool/main/g/gcc-7-cross/gcc-7-aarch64-linux-gnu_7.4.0-1ubuntu1~18.04.1cross1_amd64.deb'
DEB_NAME = 'gcc-7-aarch64-linux-gnu_7.4.0-1ubuntu1~18.04.1cross1_amd64.deb'
SRC_URI[md5sum] = "bf81ce5f519d0f4e478a41d584ebe44b"
