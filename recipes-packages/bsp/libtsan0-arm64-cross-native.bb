inherit native deb-dl

LICENSE = "EPL-1.0"

FULL_LINK = 'http://security.ubuntu.com/ubuntu/pool/main/g/gcc-8-cross/libtsan0-arm64-cross_8.3.0-6ubuntu1~18.04.1cross1_all.deb'
DEB_NAME = 'libtsan0-arm64-cross_8.3.0-6ubuntu1~18.04.1cross1_all.deb'
SRC_URI[md5sum] = "6b9a9ae5db5211ab9c9efe6b1907b076"
