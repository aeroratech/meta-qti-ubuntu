inherit native deb-dl

LICENSE = "zlib"

FULL_LINK = 'http://kr.archive.ubuntu.com/ubuntu/pool/main/z/zlib/zlib1g_1.2.11.dfsg-0ubuntu2_amd64.deb'
DEB_NAME = 'zlib1g_1.2.11.dfsg-0ubuntu2_amd64.deb'
SRC_URI[md5sum] = "816cd10960f62571551ede3f45b03d83"
