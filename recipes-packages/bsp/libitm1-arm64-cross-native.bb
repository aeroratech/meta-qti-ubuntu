inherit native deb-dl

LICENSE = "EPL-1.0"

FULL_LINK = 'http://ports.ubuntu.com/ubuntu-ports/pool/main/g/gcc-8-cross/libitm1-arm64-cross_8.3.0-6ubuntu1~18.04.1cross1_all.deb'
DEB_NAME = 'libitm1-arm64-cross_8.3.0-6ubuntu1~18.04.1cross1_all.deb'
SRC_URI[md5sum] = "a056c1de18259a50e166ea1c283a9353"
