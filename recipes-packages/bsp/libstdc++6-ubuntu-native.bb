inherit native deb-dl

LICENSE = "GPL-3.0-with-GCC-exception & GPLv3"

FULL_LINK = 'http://security.ubuntu.com/ubuntu/pool/main/g/gcc-8/libstdc++6_8.3.0-6ubuntu1~18.04.1_amd64.deb'
DEB_NAME = 'libstdc++6_8.3.0-6ubuntu1~18.04.1_amd64.deb'
SRC_URI[md5sum] = "fe767a7d9f0cf7b3db3ba0cd09386f94"
