inherit native deb-dl

LICENSE = "GPL-2.0+ & GPL-3.0+"

FULL_LINK = 'http://security.ubuntu.com/ubuntu/pool/main/g/gpm/libgpm2_1.20.7-5_amd64.deb'
DEB_NAME = 'libgpm2_1.20.7-5_amd64.deb'
SRC_URI[md5sum] = "7539b31eacf83d75e9f9fd5358786d3c"
