inherit native deb-dl

LICENSE = "GPL-3.0-with-GCC-exception & GPLv3"

FULL_LINK = 'http://security.ubuntu.com/ubuntu/pool/main/g/gcc-8/libcc1-0_8.3.0-6ubuntu1~18.04.1_amd64.deb'
DEB_NAME = 'libcc1-0_8.3.0-6ubuntu1~18.04.1_amd64.deb'
SRC_URI[md5sum] = "e81dec92e2033a8f05268b2b1fb8b787"
