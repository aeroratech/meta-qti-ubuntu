inherit deb-dl

LICENSE = "MIT"

SRC_URI[md5sum] = "8bf850902f2fbfc5be1e0bf496f759bf"

FULL_LINK = 'http://ports.ubuntu.com/ubuntu-ports/pool/main/libx/libxml2/libxml2-dev_2.9.4+dfsg1-6.1ubuntu1.4_arm64.deb'
DEB_NAME = 'libxml2-dev_2.9.4+dfsg1-6.1ubuntu1.4_arm64.deb'
