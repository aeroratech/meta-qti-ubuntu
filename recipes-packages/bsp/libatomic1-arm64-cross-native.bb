inherit native deb-dl

LICENSE = "EPL-1.0"

SRC_URI[md5sum] = "890fde020b56947c8d74da42ce0f64a1"

FULL_LINK = 'http://security.ubuntu.com/ubuntu/pool/main/g/gcc-8-cross/libatomic1-arm64-cross_8.3.0-6ubuntu1~18.04.1cross1_all.deb'
DEB_NAME = 'libatomic1-arm64-cross_8.3.0-6ubuntu1~18.04.1cross1_all.deb'
