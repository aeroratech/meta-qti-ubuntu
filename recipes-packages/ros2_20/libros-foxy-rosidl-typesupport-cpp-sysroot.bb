LICENSE = "Apache-2.0"
SRC_URI[md5sum] = "91fff8f525e408f86d9c08a755cc612f"

FULL_LINK = 'http://packages.ros.org/ros2/ubuntu/pool/main/r/ros-foxy-rosidl-typesupport-cpp/ros-foxy-rosidl-typesupport-cpp_1.0.2-1focal.20211112.181331_arm64.deb'
DEB_NAME = 'ros-foxy-rosidl-typesupport-cpp_1.0.2-1focal.20211112.181331_arm64.deb'
