LICENSE = "Apache-2.0"

SRC_URI[md5sum] = "6cb612cf5a2ad3d9e827b0d5a62c395a"

FULL_LINK = 'http://packages.ros.org/ros2/ubuntu/pool/main/r/ros-foxy-builtin-interfaces/ros-foxy-builtin-interfaces_1.0.0-1focal.20220201.004345_arm64.deb'
DEB_NAME = 'ros-foxy-builtin-interfaces_1.0.0-1focal.20220201.004345_arm64.deb'
