inherit deb-dl

LICENSE = "BSL-1.0 & BSD-3-Clause & MIT & Zlib & RSA-MD"

FULL_LINK = 'http://ports.ubuntu.com/ubuntu-ports/pool/universe/p/poco/libpocofoundation62_1.9.2-3ubuntu3_arm64.deb'

DEB_NAME = 'libpocofoundation62_1.9.2-3ubuntu3_arm64.deb'

SRC_URI[md5sum] = "5edbb68b4e5673333d6d05dc43851588"
