LICENSE = "Apache-2.0"
SRC_URI[md5sum] = "a9a9d7269f9f731e64101d319ea85d21"

FULL_LINK = 'http://packages.ros.org/ros2/ubuntu/pool/main/r/ros-foxy-rmw-implementation/ros-foxy-rmw-implementation_1.0.3-1focal.20220204.165834_arm64.deb'
DEB_NAME = 'ros-foxy-rmw-implementation_1.0.3-1focal.20220204.165834_arm64.deb'
