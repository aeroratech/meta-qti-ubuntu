LICENSE = "Apache-2.0"
SRC_URI[md5sum] = "0c3e321dfbef0e9c0ec561fd93d78f93"

FULL_LINK = 'http://packages.ros.org/ros2/ubuntu/pool/main/r/ros-foxy-rosidl-typesupport-introspection-c/ros-foxy-rosidl-typesupport-introspection-c_1.2.1-1focal.20211112.180542_arm64.deb'
DEB_NAME = 'ros-foxy-rosidl-typesupport-introspection-c_1.2.1-1focal.20211112.180542_arm64.deb'
