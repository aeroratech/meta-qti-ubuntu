LICENSE = "Apache-2.0"
SRC_URI[md5sum] = "db349037da12d04779531c5e3ece8f04"

FULL_LINK = 'http://packages.ros.org/ros2/ubuntu/pool/main/r/ros-foxy-rosidl-generator-c/ros-foxy-rosidl-generator-c_1.2.1-1focal.20211112.180539_arm64.deb'
DEB_NAME = 'ros-foxy-rosidl-generator-c_1.2.1-1focal.20211112.180539_arm64.deb'
