LICENSE = "Apache-2.0"

SRC_URI[md5sum] = "0d3ea37941fd1552e8127d4e02fe1f21"
FULL_LINK = 'http://packages.ros.org/ros2/ubuntu/pool/main/r/ros-foxy-geometry-msgs/ros-foxy-geometry-msgs_2.0.5-1focal.20220201.010236_arm64.deb'
DEB_NAME = 'ros-foxy-geometry-msgs_2.0.5-1focal.20220201.010236_arm64.deb'
