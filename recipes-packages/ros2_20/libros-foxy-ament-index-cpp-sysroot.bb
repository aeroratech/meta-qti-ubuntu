LICENSE = "Apache-2.0"
SRC_URI[md5sum] = "2e445fd14bb26531207c01966914a3f1"

FULL_LINK = 'http://packages.ros.org/ros2/ubuntu/pool/main/r/ros-foxy-ament-index-cpp/ros-foxy-ament-index-cpp_1.1.0-1focal.20210901.045716_arm64.deb'
DEB_NAME = 'ros-foxy-ament-index-cpp_1.1.0-1focal.20210901.045716_arm64.deb'
