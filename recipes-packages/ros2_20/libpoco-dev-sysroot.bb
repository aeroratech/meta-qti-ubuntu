inherit deb-dl

LICENSE = "BSL-1.0 & BSD-3-Clause & MIT & Zlib & RSA-MD"

FULL_LINK = 'http://ports.ubuntu.com/ubuntu-ports/pool/universe/p/poco/libpoco-dev_1.9.2-3ubuntu3_arm64.deb'

DEB_NAME = 'libpoco-dev_1.9.2-3ubuntu3_arm64.deb'

SRC_URI[md5sum] = "a29e46c931075812a2d8e5fd78e6b730"
