LICENSE = "Apache-2.0"	

SRC_URI[md5sum] = "2043781cf2b0f454ee2a22b8bf1882f8"

FULL_LINK = 'http://packages.ros.org/ros2/ubuntu/pool/main/r/ros-foxy-rcl-logging-spdlog/ros-foxy-rcl-logging-spdlog_1.1.0-1focal.20220115.045201_arm64.deb'
DEB_NAME = 'ros-foxy-rcl-logging-spdlog_1.1.0-1focal.20220115.045201_arm64.deb'
