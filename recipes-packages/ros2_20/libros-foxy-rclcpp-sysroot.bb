LICENSE = "Apache-2.0"
SRC_URI[md5sum] = "98111d925991ccdfdda762b941e050a2"

FULL_LINK = 'http://packages.ros.org/ros2/ubuntu/pool/main/r/ros-foxy-rclcpp/ros-foxy-rclcpp_2.4.0-1focal.20211112.185137_arm64.deb'
DEB_NAME = 'ros-foxy-rclcpp_2.4.0-1focal.20211112.185137_arm64.deb'
