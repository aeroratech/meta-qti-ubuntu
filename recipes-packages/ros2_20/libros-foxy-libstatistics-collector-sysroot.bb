LICENSE = "Apache-2.0"
SRC_URI[md5sum] = "0ab3702e3be76fd7b47c68d407367576"

FULL_LINK = 'http://packages.ros.org/ros2/ubuntu/pool/main/r/ros-foxy-libstatistics-collector/ros-foxy-libstatistics-collector_1.0.1-1focal.20220204.170542_arm64.deb'
DEB_NAME = 'ros-foxy-libstatistics-collector_1.0.1-1focal.20220204.170542_arm64.deb'
