LICENSE = "Apache-2.0"
SRC_URI[md5sum] = "e9c5bc6b6b62e87065434a447fe62391"

FULL_LINK = 'http://packages.ros.org/ros2/ubuntu/pool/main/r/ros-foxy-rosidl-generator-cpp/ros-foxy-rosidl-generator-cpp_1.2.1-1focal.20220115.051002_arm64.deb'
DEB_NAME = 'ros-foxy-rosidl-generator-cpp_1.2.1-1focal.20220115.051002_arm64.deb'
