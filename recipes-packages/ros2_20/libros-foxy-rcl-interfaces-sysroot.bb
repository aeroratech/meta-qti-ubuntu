LICENSE = "Apache-2.0"

SRC_URI[md5sum] = "0c4a551c5a9bff7f83741dbf5f98157b"

FULL_LINK = 'http://packages.ros.org/ros2/ubuntu/pool/main/r/ros-foxy-rcl-interfaces/ros-foxy-rcl-interfaces_1.0.0-1focal.20211112.182115_arm64.deb'
DEB_NAME = 'ros-foxy-rcl-interfaces_1.0.0-1focal.20211112.182115_arm64.deb'
