LICENSE = "Apache-2.0"

SRC_URI[md5sum] = "de90314ff85d8ec81aabbf8d17dc0ef9"

FULL_LINK = 'http://packages.ros.org/ros2/ubuntu/pool/main/r/ros-foxy-rcl-logging-noop/ros-foxy-rcl-logging-noop_1.1.0-1focal.20211112.180349_arm64.deb'
DEB_NAME = 'ros-foxy-rcl-logging-noop_1.1.0-1focal.20211112.180349_arm64.deb'
