
LICENSE = "BSD-3-Clause"

FULL_LINK = 'http://packages.ros.org/ros2/ubuntu/pool/main/p/python3-catkin-pkg-modules/python3-catkin-pkg-modules_0.4.24-1_all.deb'
DEB_NAME = 'python3-catkin-pkg-modules_0.4.24-1_all.deb'

SRC_URI[md5sum] = "4972e51cacef257f9885cdc28e87918d"
