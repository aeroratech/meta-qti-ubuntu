LICENSE = "Apache-2.0"
SRC_URI[md5sum] = "22c59faf712888c5c3766cc3048aadf7"

FULL_LINK = 'http://packages.ros.org/ros2/ubuntu/pool/main/r/ros-foxy-rosidl-runtime-cpp/ros-foxy-rosidl-runtime-cpp_1.2.1-1focal.20210901.044952_arm64.deb'
DEB_NAME = 'ros-foxy-rosidl-runtime-cpp_1.2.1-1focal.20210901.044952_arm64.deb'
