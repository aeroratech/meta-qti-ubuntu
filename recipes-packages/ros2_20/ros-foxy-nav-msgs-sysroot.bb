LICENSE = "Apache-2.0"

FULL_LINK = 'http://packages.ros.org/ros2/ubuntu/pool/main/r/ros-foxy-nav-msgs/ros-foxy-nav-msgs_2.0.4-1focal.20211112.185842_arm64.deb'
DEB_NAME = 'ros-foxy-nav-msgs_2.0.4-1focal.20211112.185842_arm64.deb'

SRC_URI[md5sum] = "851cb4dda063a1cdbf4fe87266813d5e"
