LICENSE = "Apache-2.0"
SRC_URI[md5sum] = "2e33630a2c0305d4bbde4afdedfdddb5"

FULL_LINK = 'http://packages.ros.org/ros2/ubuntu/pool/main/r/ros-foxy-rosidl-runtime-c/ros-foxy-rosidl-runtime-c_1.2.1-1focal.20220115.045428_arm64.deb'
DEB_NAME = 'ros-foxy-rosidl-runtime-c_1.2.1-1focal.20220115.045428_arm64.deb'
