LICENSE = "BSD"
SRC_URI[md5sum] = "8b0a4d93a83660af8a369614b6281c05"

FULL_LINK = 'http://packages.ros.org/ros2/ubuntu/pool/main/r/ros-foxy-image-transport/ros-foxy-image-transport_2.3.0-1focal.20211112.201006_arm64.deb'
DEB_NAME = 'ros-foxy-image-transport_2.3.0-1focal.20211112.201006_arm64.deb'
