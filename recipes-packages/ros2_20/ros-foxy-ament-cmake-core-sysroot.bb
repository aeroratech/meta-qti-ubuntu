LICENSE = "Apache-2.0"

FULL_LINK = 'http://packages.ros.org/ros2/ubuntu/pool/main/r/ros-foxy-ament-cmake-core/ros-foxy-ament-cmake-core_0.9.9-1focal.20210901.015622_arm64.deb'
DEB_NAME = 'ros-foxy-ament-cmake-core_0.9.9-1focal.20210901.015622_arm64.deb'

SRC_URI[md5sum] = "0934fe8cebd9a9a2c6088844edf99be7"
