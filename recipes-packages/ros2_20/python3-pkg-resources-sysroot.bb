inherit deb-dl

LICENSE = "PSF | ZPL"

FULL_LINK = 'http://ports.ubuntu.com/ubuntu-ports/pool/main/s/setuptools/python3-pkg-resources_45.2.0-1_all.deb'

DEB_NAME = 'python3-pkg-resources_45.2.0-1_all.deb'

SRC_URI[md5sum] = "ef274536b09b191ca3c7e66f235b9b24"
