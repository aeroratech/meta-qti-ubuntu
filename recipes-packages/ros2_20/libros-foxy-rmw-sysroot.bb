LICENSE = "Apache-2.0"
SRC_URI[md5sum] = "408229f1fa6b52819fecccee023043e3"

FULL_LINK = 'http://packages.ros.org/ros2/ubuntu/pool/main/r/ros-foxy-rmw/ros-foxy-rmw_1.0.3-1focal.20220115.050344_arm64.deb'
DEB_NAME = 'ros-foxy-rmw_1.0.3-1focal.20220115.050344_arm64.deb'
