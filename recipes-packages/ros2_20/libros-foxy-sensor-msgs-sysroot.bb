LICENSE = "Apache-2.0"
SRC_URI[md5sum] = "64dac461e33049efc15d191f132a9cd8"

FULL_LINK = 'http://packages.ros.org/ros2/ubuntu/pool/main/r/ros-foxy-sensor-msgs/ros-foxy-sensor-msgs_2.0.4-1focal.20211112.190447_arm64.deb'
DEB_NAME = 'ros-foxy-sensor-msgs_2.0.4-1focal.20211112.190447_arm64.deb'
