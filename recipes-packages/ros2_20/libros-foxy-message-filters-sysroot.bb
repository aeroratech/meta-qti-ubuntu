LICENSE = "BSD"
SRC_URI[md5sum] = "930db940c55dbe7ccc1b7bb8b94dc8cb"

FULL_LINK = 'http://packages.ros.org/ros2/ubuntu/pool/main/r/ros-foxy-message-filters/ros-foxy-message-filters_3.2.5-1focal.20220204.172735_arm64.deb'
DEB_NAME = 'ros-foxy-message-filters_3.2.5-1focal.20220204.172735_arm64.deb'
