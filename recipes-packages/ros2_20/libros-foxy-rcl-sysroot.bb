LICENSE = "Apache-2.0"
SRC_URI[md5sum] = "e6356192513ee0d44a854b8b11574195"

FULL_LINK = 'http://packages.ros.org/ros2/ubuntu/pool/main/r/ros-foxy-rcl/ros-foxy-rcl_1.1.13-1focal.20220209.143852_arm64.deb'
DEB_NAME = 'ros-foxy-rcl_1.1.13-1focal.20220209.143852_arm64.deb'
