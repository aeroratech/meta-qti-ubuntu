LICENSE = "Apache-2.0"
SRC_URI[md5sum] = "01201299eb2d892b8a2cf49959edf966"

FULL_LINK = 'http://packages.ros.org/ros2/ubuntu/pool/main/r/ros-foxy-statistics-msgs/ros-foxy-statistics-msgs_1.0.0-1focal.20211112.182621_arm64.deb'
DEB_NAME = 'ros-foxy-statistics-msgs_1.0.0-1focal.20211112.182621_arm64.deb'
