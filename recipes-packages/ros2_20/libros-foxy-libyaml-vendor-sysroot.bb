LICENSE = "MIT & Apache-2.0"

SRC_URI[md5sum] = "9b9c97da1b54e20630dcf53c6a56e9ac"

FULL_LINK = 'http://packages.ros.org/ros2/ubuntu/pool/main/r/ros-foxy-libyaml-vendor/ros-foxy-libyaml-vendor_1.0.4-1focal.20211112.180756_arm64.deb'
DEB_NAME = 'ros-foxy-libyaml-vendor_1.0.4-1focal.20211112.180756_arm64.deb'
