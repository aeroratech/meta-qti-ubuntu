LICENSE = "Apache-2.0"
SRC_URI[md5sum] = "8811e8b209c8d2e9ab1962ca86ff4960"

FULL_LINK = 'http://packages.ros.org/ros2/ubuntu/pool/main/r/ros-foxy-rcl-yaml-param-parser/ros-foxy-rcl-yaml-param-parser_1.1.11-1focal.20211112.181029_arm64.deb'
DEB_NAME = 'ros-foxy-rcl-yaml-param-parser_1.1.11-1focal.20211112.181029_arm64.deb'
