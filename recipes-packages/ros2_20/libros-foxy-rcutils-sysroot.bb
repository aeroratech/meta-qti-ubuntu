LICENSE = "Apache-2.0"
SRC_URI[md5sum] = "f85cf391bfddbaf4e2d8607aee112180"

FULL_LINK = 'http://packages.ros.org/ros2/ubuntu/pool/main/r/ros-foxy-rcutils/ros-foxy-rcutils_1.1.3-1focal.20220112.193041_arm64.deb'
DEB_NAME = 'ros-foxy-rcutils_1.1.3-1focal.20220112.193041_arm64.deb'
