LICENSE = "BSD"
SRC_URI[md5sum] = "6b453fb3f43bdb6dd1b7862de8301a5a"

FULL_LINK = 'http://packages.ros.org/ros2/ubuntu/pool/main/r/ros-foxy-class-loader/ros-foxy-class-loader_2.0.2-1focal.20211112.180716_arm64.deb'
DEB_NAME = 'ros-foxy-class-loader_2.0.2-1focal.20211112.180716_arm64.deb'
