LICENSE = "Apache-2.0"
SRC_URI[md5sum] = "2922cc6564b01387d6fe8abcb5a08b02"

FULL_LINK = 'http://packages.ros.org/ros2/ubuntu/pool/main/r/ros-foxy-rosidl-typesupport-c/ros-foxy-rosidl-typesupport-c_1.0.2-1focal.20211112.181200_arm64.deb'
DEB_NAME = 'ros-foxy-rosidl-typesupport-c_1.0.2-1focal.20211112.181200_arm64.deb'
