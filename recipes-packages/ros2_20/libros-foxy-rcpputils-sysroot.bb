LICENSE = "Apache-2.0"
SRC_URI[md5sum] = "cb9266f972bb992dc80c702129d03863"

FULL_LINK = 'http://packages.ros.org/ros2/ubuntu/pool/main/r/ros-foxy-rcpputils/ros-foxy-rcpputils_1.3.2-1focal.20220112.193329_arm64.deb'
DEB_NAME = 'ros-foxy-rcpputils_1.3.2-1focal.20220112.193329_arm64.deb'
