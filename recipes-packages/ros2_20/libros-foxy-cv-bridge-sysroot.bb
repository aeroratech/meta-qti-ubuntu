LICENSE = "BSD"
SRC_URI[md5sum] = "76fc11d226e103880fef43885cd79393"

FULL_LINK = 'http://packages.ros.org/ros2/ubuntu/pool/main/r/ros-foxy-cv-bridge/ros-foxy-cv-bridge_2.2.1-1focal.20220201.013418_arm64.deb'
DEB_NAME = 'ros-foxy-cv-bridge_2.2.1-1focal.20220201.013418_arm64.deb'
