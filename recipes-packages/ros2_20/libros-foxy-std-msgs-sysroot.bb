LICENSE = "Apache-2.0"
SRC_URI[md5sum] = "4ad1ace9937cb919cb7f2c0726e98c81"

FULL_LINK = 'http://packages.ros.org/ros2/ubuntu/pool/main/r/ros-foxy-std-msgs/ros-foxy-std-msgs_2.0.5-1focal.20220201.005254_arm64.deb'
DEB_NAME = 'ros-foxy-std-msgs_2.0.5-1focal.20220201.005254_arm64.deb'
