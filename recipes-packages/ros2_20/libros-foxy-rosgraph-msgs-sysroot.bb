LICENSE = "Apache-2.0"

SRC_URI[md5sum] = "172eb004050368e97f4566761c5c21a8"

FULL_LINK = 'http://packages.ros.org/ros2/ubuntu/pool/main/r/ros-foxy-rosgraph-msgs/ros-foxy-rosgraph-msgs_1.0.0-1focal.20220201.005220_arm64.deb'
DEB_NAME = 'ros-foxy-rosgraph-msgs_1.0.0-1focal.20220201.005220_arm64.deb'
