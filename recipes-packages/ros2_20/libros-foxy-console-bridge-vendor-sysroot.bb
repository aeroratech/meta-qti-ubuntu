LICENSE = "Apache-2.0 & BSD"
SRC_URI[md5sum] = "03804d74629e32ae62e8976932b6257a"

FULL_LINK = 'http://packages.ros.org/ros2/ubuntu/pool/main/r/ros-foxy-console-bridge-vendor/ros-foxy-console-bridge-vendor_1.2.4-1focal.20220115.045853_arm64.deb'
DEB_NAME = 'ros-foxy-console-bridge-vendor_1.2.4-1focal.20220115.045853_arm64.deb'
