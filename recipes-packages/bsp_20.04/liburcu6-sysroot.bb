inherit deb-dl

LICENSE = "LGPL-2.1+ & GPL-3.0+ & MIT & GPL-2.0+"

FULL_LINK = 'http://ports.ubuntu.com/ubuntu-ports/pool/main/libu/liburcu/liburcu6_0.11.1-2_arm64.deb'

DEB_NAME = 'liburcu6_0.11.1-2_arm64.deb'

SRC_URI[md5sum] = "c882f21da16ecf644541cadcc1e50b56"
