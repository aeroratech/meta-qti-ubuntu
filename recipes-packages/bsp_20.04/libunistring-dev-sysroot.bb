inherit deb-dl

LICENSE = "LGPL-3.0+ | GPL-2.0+ & GPL-3.0+ | GFDL-1.2+ & MIT"

FULL_LINK = 'http://ports.ubuntu.com/ubuntu-ports/pool/main/libu/libunistring/libunistring-dev_0.9.10-2_arm64.deb'

DEB_NAME = 'libunistring-dev_0.9.10-2_arm64.deb'

SRC_URI[md5sum] = "431f6a68ffb8a395df01d2eba454c76b"
