inherit deb-dl

LICENSE = "LGPL-2.1+ & CCO-1.0 & GPL-2.0+ & GPL-2.0-with-Linux-syscall-note-exception & MIT & PD"

FULL_LINK = 'http://ports.ubuntu.com/ubuntu-ports/pool/main/s/systemd/libudev1_245.4-4ubuntu3_arm64.deb'

DEB_NAME = 'libudev1_245.4-4ubuntu3_arm64.deb'

SRC_URI[md5sum] = "f750bc30c679345815aee5739232116d"
