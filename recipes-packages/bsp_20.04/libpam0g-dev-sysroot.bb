inherit deb-dl

LICENSE = "BSD-3-Clause"

FULL_LINK = 'http://ports.ubuntu.com/ubuntu-ports/pool/main/p/pam/libpam0g-dev_1.3.1-5ubuntu4_arm64.deb'

DEB_NAME = 'libpam0g-dev_1.3.1-5ubuntu4_arm64.deb'

SRC_URI[md5sum] = "f4366724853ca5c579d7c7d940875126"
