inherit deb-dl

LICENSE = "BSD-3-Clause"

FULL_LINK = 'http://ports.ubuntu.com/ubuntu-ports/pool/main/libv/libvorbis/libvorbisfile3_1.3.6-2ubuntu1_arm64.deb'

DEB_NAME = 'libvorbisfile3_1.3.6-2ubuntu1_arm64.deb'

SRC_URI[md5sum] = "9c1382f25b33719247d47a090636d128"
