inherit deb-dl

LICENSE = "MIT"

FULL_LINK = 'http://ports.ubuntu.com/ubuntu-ports/pool/main/j/json-c/libjson-c-dev_0.13.1+dfsg-7_arm64.deb'

DEB_NAME = 'libjson-c-dev_0.13.1+dfsg-7_arm64.deb'

SRC_URI[md5sum] = "d7194e64a69d5cc16c7bc8f46c12cc68"
