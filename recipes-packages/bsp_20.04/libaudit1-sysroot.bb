inherit deb-dl

LICENSE = "GPL-2.0+"

FULL_LINK = 'http://ports.ubuntu.com/ubuntu-ports/pool/main/a/audit/libaudit1_2.8.5-2ubuntu6_arm64.deb'

DEB_NAME = 'libaudit1_2.8.5-2ubuntu6_arm64.deb'

SRC_URI[md5sum] = "7f0b1c0a50ab32de808d7bacec0fb12d"
