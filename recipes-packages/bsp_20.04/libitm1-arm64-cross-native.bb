inherit native deb-dl

LICENSE = "EPL-1.0"

FULL_LINK = 'http://ports.ubuntu.com/ubuntu-ports/pool/main/g/gcc-10-cross/libitm1-arm64-cross_10.3.0-1ubuntu1~20.04cross1_all.deb'

DEB_NAME = 'libitm1-arm64-cross_10.3.0-1ubuntu1~20.04cross1_all.deb'

SRC_URI[md5sum] = "53b978a4cccef7ead5f47dd31c72e2ca"
