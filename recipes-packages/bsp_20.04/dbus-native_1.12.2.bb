inherit native


LICENSE = "GPL-2.0+ | AFL-2.1"

do_install() {
   bbnote install complete;
}
