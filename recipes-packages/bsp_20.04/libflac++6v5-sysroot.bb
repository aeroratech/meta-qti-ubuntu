inherit deb-dl

LICENSE = "GFDL-1.1+ & BSD-3-Clause & GPL-2+ & LGPL-2.1+ & PD & ISC"

FULL_LINK = 'http://ports.ubuntu.com/ubuntu-ports/pool/main/f/flac/libflac++6v5_1.3.3-1build1_arm64.deb'

DEB_NAME = 'libflac++6v5_1.3.3-1build1_arm64.deb'

SRC_URI[md5sum] = "6fe6829a0b416c4bda02b720151c7021"
