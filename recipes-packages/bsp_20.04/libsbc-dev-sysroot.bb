inherit deb-dl

LICENSE = "GPL-2.0+ & LGPL-2.0+"

FULL_LINK = 'http://ports.ubuntu.com/ubuntu-ports/pool/main/s/sbc/libsbc-dev_1.4-1_arm64.deb'

DEB_NAME = 'libsbc-dev_1.4-1_arm64.deb'

SRC_URI[md5sum] = "db18e08f0d60234761e93df24e35263a"
