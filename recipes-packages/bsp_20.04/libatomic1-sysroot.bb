inherit deb-dl

LICENSE = "GPL-3.0-with-GCC-exception"

FULL_LINK = 'http://ports.ubuntu.com/ubuntu-ports/pool/main/g/gcc-10/libatomic1_10-20200411-0ubuntu1_arm64.deb'

DEB_NAME = 'libatomic1_10-20200411-0ubuntu1_arm64.deb'

SRC_URI[md5sum] = "9480be3c89c5dadb0af69d93c1507f75"
