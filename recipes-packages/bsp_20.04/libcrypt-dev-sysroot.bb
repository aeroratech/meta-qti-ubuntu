inherit deb-dl

LICENSE = " LGPL-2.1+"

FULL_LINK = 'http://ports.ubuntu.com/ubuntu-ports/pool/main/libx/libxcrypt/libcrypt-dev_4.4.10-10ubuntu4_arm64.deb'

DEB_NAME = 'libcrypt-dev_4.4.10-10ubuntu4_arm64.deb'

SRC_URI[md5sum] = "e7b9c19b2315949aa7898e2cab9fd063"
