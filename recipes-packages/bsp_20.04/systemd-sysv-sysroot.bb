inherit deb-dl

LICENSE = "LGPL-2.1+ & CCO-1.0 & GPL-2-with-Linux-syscall-note-exception & GPL-2.0+"

FULL_LINK = 'http://ports.ubuntu.com/ubuntu-ports/pool/main/s/systemd/systemd-sysv_245.4-4ubuntu3_arm64.deb'

DEB_NAME = 'systemd-sysv_245.4-4ubuntu3_arm64.deb'

SRC_URI[md5sum] = "f99b837a47e6c73a384a2c23ebcdeb98"
