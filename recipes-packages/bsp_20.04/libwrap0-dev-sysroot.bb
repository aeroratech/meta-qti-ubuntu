inherit deb-dl

LICENSE = "Various licenses"

LIC_FILES_CHKSUM = "\
    file://https://changelogs.ubuntu.com/changelogs/pool/main/t/tcp-wrappers/tcp-wrappers_7.6.q-30/copyright;md5=aebfac90929f6a69f2aa763213476b7d \
"

FULL_LINK = 'http://ports.ubuntu.com/ubuntu-ports/pool/main/t/tcp-wrappers/libwrap0-dev_7.6.q-30_arm64.deb'

DEB_NAME = 'libwrap0-dev_7.6.q-30_arm64.deb'

SRC_URI[md5sum] = "b5a890cee8bb33d2619c9e73e62b0571"
