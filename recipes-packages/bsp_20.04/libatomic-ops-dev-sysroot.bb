inherit deb-dl

LICENSE = "GPL-2.0 & MIT"

FULL_LINK = 'http://ports.ubuntu.com/ubuntu-ports/pool/main/liba/libatomic-ops/libatomic-ops-dev_7.6.10-1ubuntu2_arm64.deb'

DEB_NAME = 'libatomic-ops-dev_7.6.10-1ubuntu2_arm64.deb'

SRC_URI[md5sum] = "f3734131dbae295d2bd5258340485763"
