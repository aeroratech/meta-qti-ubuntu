inherit deb-dl

LICENSE = "GPL-2.0+ & MIT"

FULL_LINK = 'http://ports.ubuntu.com/ubuntu-ports/pool/main/libi/libinput/libinput-dev_1.15.5-1_arm64.deb'

DEB_NAME = 'libinput-dev_1.15.5-1_arm64.deb'

SRC_URI[md5sum] = "8cd1c4541f6c1fe41c4402beedab204c"
