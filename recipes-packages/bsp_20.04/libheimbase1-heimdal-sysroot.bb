inherit deb-dl

LICENSE = "BSD-3-Clause & GPL-2.0+"

FULL_LINK = 'http://ports.ubuntu.com/ubuntu-ports/pool/main/h/heimdal/libheimbase1-heimdal_7.7.0+dfsg-1ubuntu1_arm64.deb'

DEB_NAME = 'libheimbase1-heimdal_7.7.0+dfsg-1ubuntu1_arm64.deb'

SRC_URI[md5sum] = "1e294462d0573c4008d202a0a2b0f911"
