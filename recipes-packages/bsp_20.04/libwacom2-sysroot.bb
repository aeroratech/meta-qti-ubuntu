inherit deb-dl

LICENSE = "MIT"

FULL_LINK = 'http://ports.ubuntu.com/ubuntu-ports/pool/main/libw/libwacom/libwacom2_1.3-2ubuntu1_arm64.deb'

DEB_NAME = 'libwacom2_1.3-2ubuntu1_arm64.deb'

SRC_URI[md5sum] = "ba07c624b98d648fbb74d400d819199b"
