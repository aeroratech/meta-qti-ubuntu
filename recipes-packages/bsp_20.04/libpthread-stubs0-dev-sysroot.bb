inherit deb-dl

LICENSE = " MIT"

FULL_LINK = 'http://ports.ubuntu.com/ubuntu-ports/pool/main/libp/libpthread-stubs/libpthread-stubs0-dev_0.4-1_arm64.deb'

DEB_NAME = 'libpthread-stubs0-dev_0.4-1_arm64.deb'

SRC_URI[md5sum] = "93dbd5c581ed753f34c2cc84253d3069"
