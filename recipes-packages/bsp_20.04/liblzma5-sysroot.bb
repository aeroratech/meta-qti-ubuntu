inherit deb-dl

LICENSE = "LGPL-2.1+ & GPL-2.0+ & GPL-3.0+ & PD"

FULL_LINK = 'http://ports.ubuntu.com/ubuntu-ports/pool/main/x/xz-utils/liblzma5_5.2.4-1_arm64.deb'

DEB_NAME = 'liblzma5_5.2.4-1_arm64.deb'

SRC_URI[md5sum] = "e92de24a196bfa4657b40f5f72156c96"
