inherit deb-dl

LICENSE = "Zlib"

FULL_LINK = 'http://ports.ubuntu.com/ubuntu-ports/pool/main/z/zlib/zlib1g_1.2.11.dfsg-2ubuntu1_arm64.deb'

DEB_NAME = 'zlib1g_1.2.11.dfsg-2ubuntu1_arm64.deb'

SRC_URI[md5sum] = "8b5d376fa23b25fc3b0e95c21695b659"
