inherit deb-dl

LICENSE = "GPL-2.0+ & MIT"

FULL_LINK = 'http://ports.ubuntu.com/ubuntu-ports/pool/main/libi/libinput/libinput10_1.15.5-1_arm64.deb'

DEB_NAME = 'libinput10_1.15.5-1_arm64.deb'

SRC_URI[md5sum] = "098e4f972b3e87d3380952d9a31852c6"
