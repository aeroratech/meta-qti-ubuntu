inherit deb-dl

LICENSE = "MIT & SGI-B-2.0 & BSD & Apache-2.0 & BSL-1.0"

FULL_LINK = 'http://ports.ubuntu.com/ubuntu-ports/pool/main/m/mesa/libgbm1_20.0.4-2ubuntu1_arm64.deb'

DEB_NAME = 'libgbm1_20.0.4-2ubuntu1_arm64.deb'

SRC_URI[md5sum] = "4859a8c7dc8bdf33ee725ff671d62202"
