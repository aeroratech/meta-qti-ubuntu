inherit deb-dl

LICENSE = "GPL-2.0+ | AFL-2.1"

FULL_LINK = 'http://ports.ubuntu.com/ubuntu-ports/pool/main/d/dbus/libdbus-1-dev_1.12.16-2ubuntu2_arm64.deb'

DEB_NAME = 'libdbus-1-dev_1.12.16-2ubuntu2_arm64.deb'

SRC_URI[md5sum] = "49d6b7c6c1ee535e6c7ebde6052d1fd2"
