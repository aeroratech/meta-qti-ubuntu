inherit deb-dl

LICENSE = "LGPL-2.1 | MPL-1.1 & BSD-2-clause"

FULL_LINK = 'http://ports.ubuntu.com/ubuntu-ports/pool/main/t/taglib/libtag1-dev_1.11.1+dfsg.1-0.3ubuntu2_arm64.deb'

DEB_NAME = 'libtag1-dev_1.11.1+dfsg.1-0.3ubuntu2_arm64.deb'

SRC_URI[md5sum] = "c56993b15b001672498f4d89665e904e"
