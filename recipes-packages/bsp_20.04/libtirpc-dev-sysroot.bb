inherit deb-dl

LICENSE = "GPL-2.0 & LGPL-2.1+ & BSD-3-clause & BSD-2-clause & BSD-4-clause"

FULL_LINK = 'http://ports.ubuntu.com/ubuntu-ports/pool/main/libt/libtirpc/libtirpc-dev_1.2.5-1_arm64.deb'

DEB_NAME = 'libtirpc-dev_1.2.5-1_arm64.deb'

SRC_URI[md5sum] = "bf81ca59f04e45aa5e3712dc442ce4e7"
