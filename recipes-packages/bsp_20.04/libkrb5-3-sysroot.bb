inherit deb-dl

LICENSE = "MIT & BSD-3-Clause & more"

FULL_LINK = 'http://ports.ubuntu.com/ubuntu-ports/pool/main/k/krb5/libkrb5-3_1.17-6ubuntu4_arm64.deb'

DEB_NAME = 'libkrb5-3_1.17-6ubuntu4_arm64.deb'

SRC_URI[md5sum] = "2bd8c06e3ee2e229f601d345fc830bdb"
