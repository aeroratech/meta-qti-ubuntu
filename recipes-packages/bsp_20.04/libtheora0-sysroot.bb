inherit deb-dl

LICENSE = "BSD-3-Clause"

FULL_LINK = 'http://ports.ubuntu.com/ubuntu-ports/pool/main/libt/libtheora/libtheora0_1.1.1+dfsg.1-15ubuntu2_arm64.deb'

DEB_NAME = 'libtheora0_1.1.1+dfsg.1-15ubuntu2_arm64.deb'

SRC_URI[md5sum] = "dc1243674d0610c1744b8ee2c908c3ce"
