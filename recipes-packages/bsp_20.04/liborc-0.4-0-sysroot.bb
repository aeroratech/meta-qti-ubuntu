inherit deb-dl

LICENSE = "BSD-3-Clause & BSD-2-clause"

FULL_LINK = 'http://ports.ubuntu.com/ubuntu-ports/pool/main/o/orc/liborc-0.4-0_0.4.31-1_arm64.deb'

DEB_NAME = 'liborc-0.4-0_0.4.31-1_arm64.deb'

SRC_URI[md5sum] = "e1e63efe934c27e54f9be666a1640fe9"
