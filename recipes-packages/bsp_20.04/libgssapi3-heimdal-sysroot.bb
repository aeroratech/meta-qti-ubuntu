inherit deb-dl

LICENSE = "BSD-3-Clause & GPL-2.0+"

FULL_LINK = 'http://ports.ubuntu.com/ubuntu-ports/pool/main/h/heimdal/libgssapi3-heimdal_7.7.0+dfsg-1ubuntu1_arm64.deb'

DEB_NAME = 'libgssapi3-heimdal_7.7.0+dfsg-1ubuntu1_arm64.deb'

SRC_URI[md5sum] = "6d40f88e5311df112f598816205a6bed"
