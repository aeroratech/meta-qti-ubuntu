inherit deb-dl

LICENSE = "MIT"

FULL_LINK = 'http://ports.ubuntu.com/ubuntu-ports/pool/main/j/json-c/libjson-c4_0.13.1+dfsg-7_arm64.deb'

DEB_NAME = 'libjson-c4_0.13.1+dfsg-7_arm64.deb'

SRC_URI[md5sum] = "f76eb32dc35d1bfd639b8eea866dbd4e"
