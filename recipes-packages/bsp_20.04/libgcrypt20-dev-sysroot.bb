inherit deb-dl

LICENSE = "LGPL-2.1+ & GPL-2.0+"

FULL_LINK = 'http://ports.ubuntu.com/ubuntu-ports/pool/main/libg/libgcrypt20/libgcrypt20-dev_1.8.5-5ubuntu1_arm64.deb'

DEB_NAME = 'libgcrypt20-dev_1.8.5-5ubuntu1_arm64.deb'

SRC_URI[md5sum] = "210044bb48a6629b772c1ba4a71c8b4a"
