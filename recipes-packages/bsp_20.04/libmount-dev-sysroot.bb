inherit deb-dl

LICENSE = "GPL-2.0+"

FULL_LINK = 'http://ports.ubuntu.com/ubuntu-ports/pool/main/u/util-linux/libmount-dev_2.34-0.1ubuntu9_arm64.deb'

DEB_NAME = 'libmount-dev_2.34-0.1ubuntu9_arm64.deb'

SRC_URI[md5sum] = "16cfac0766b139c37171a08e3d483982"
