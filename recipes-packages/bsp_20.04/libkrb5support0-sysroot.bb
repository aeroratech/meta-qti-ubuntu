inherit deb-dl

LICENSE = "MIT & BSD-3-Clause & more"

FULL_LINK = 'http://ports.ubuntu.com/ubuntu-ports/pool/main/k/krb5/libkrb5support0_1.17-6ubuntu4_arm64.deb'

DEB_NAME = 'libkrb5support0_1.17-6ubuntu4_arm64.deb'

SRC_URI[md5sum] = "bf3cc4a52fca46d2b0fbc2e47cdd9373"
