inherit deb-dl

LICENSE = "GPL-2.0+ & PD & BSD-3-clause & BSD-2-clause & LGPL-2.1+ & GPL-3.0+ & MIT"

FULL_LINK = 'http://ports.ubuntu.com/ubuntu-ports/pool/main/u/util-linux/libuuid1_2.34-0.1ubuntu9_arm64.deb'

DEB_NAME = 'libuuid1_2.34-0.1ubuntu9_arm64.deb'

SRC_URI[md5sum] = "9cc15f966a9a6f7659ca55dc3d627334"
