inherit deb-dl

LICENSE = "MIT"

FULL_LINK = 'http://ports.ubuntu.com/ubuntu-ports/pool/main/e/expat/libexpat1_2.2.9-1build1_arm64.deb'

DEB_NAME = 'libexpat1_2.2.9-1build1_arm64.deb'

SRC_URI[md5sum] = "f14e6aec3905e43d3c80cddc9ed61b95"
