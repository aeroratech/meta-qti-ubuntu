inherit deb-dl

LICENSE = "LGPL-3.0+ | GPL-2.0+ & GPL-3.0+ | GFDL-1.2+ & MIT"

FULL_LINK = 'http://ports.ubuntu.com/ubuntu-ports/pool/main/libu/libunistring/libunistring2_0.9.10-2_arm64.deb'

DEB_NAME = 'libunistring2_0.9.10-2_arm64.deb'

SRC_URI[md5sum] = "418c1646f62589ef1e0755f1e1653d93"
