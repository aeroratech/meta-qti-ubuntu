inherit deb-dl

LICENSE = "BSL-1.0 & PD"

FULL_LINK = 'http://ports.ubuntu.com/ubuntu-ports/pool/universe/libc/libcrypto++/libcrypto++6_5.6.4-9build1_arm64.deb'

DEB_NAME = 'libcrypto++6_5.6.4-9build1_arm64.deb'

SRC_URI[md5sum] = "ed2ed53eaf74bc7edf0d146c9dd74440"
