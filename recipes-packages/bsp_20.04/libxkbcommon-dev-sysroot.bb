inherit deb-dl

LICENSE = "MIT-style"

FULL_LINK = 'http://ports.ubuntu.com/ubuntu-ports/pool/main/libx/libxkbcommon/libxkbcommon-dev_0.10.0-1_arm64.deb'

DEB_NAME = 'libxkbcommon-dev_0.10.0-1_arm64.deb'

SRC_URI[md5sum] = "f6032e6420c206e8db71412ae47c859a"
