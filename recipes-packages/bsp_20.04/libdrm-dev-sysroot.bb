inherit deb-dl

LICENSE = "MIT"

FULL_LINK = 'http://ports.ubuntu.com/ubuntu-ports/pool/main/libd/libdrm/libdrm-dev_2.4.101-2_arm64.deb'

DEB_NAME = 'libdrm-dev_2.4.101-2_arm64.deb'

SRC_URI[md5sum] = "2518de48c591e1dff12aba5ce6e6f74f"
