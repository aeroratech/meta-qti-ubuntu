inherit deb-dl

LICENSE = "curl & BSD-3-clause & ISC & BSD-4-Clause"

FULL_LINK = 'http://ports.ubuntu.com/ubuntu-ports/pool/main/c/curl/libcurl4-openssl-dev_7.68.0-1ubuntu2_arm64.deb'

DEB_NAME = 'libcurl4-openssl-dev_7.68.0-1ubuntu2_arm64.deb'

SRC_URI[md5sum] = "2434f87d648ce75805d276fbaf06e487"
