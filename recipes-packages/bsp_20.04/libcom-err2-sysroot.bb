inherit deb-dl

LICENSE = "GPL-2.0 & LGPL-2.0 & BSD-3-Clause & MIT"

FULL_LINK = 'http://ports.ubuntu.com/ubuntu-ports/pool/main/e/e2fsprogs/libcom-err2_1.45.5-2ubuntu1_arm64.deb'

DEB_NAME = 'libcom-err2_1.45.5-2ubuntu1_arm64.deb'

SRC_URI[md5sum] = "aec59f841abdd13c97db2f6ef467434f"
