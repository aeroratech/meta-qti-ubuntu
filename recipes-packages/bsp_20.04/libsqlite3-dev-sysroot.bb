inherit deb-dl

LICENSE = "PD & GPL-2.0+"

FULL_LINK = 'http://ports.ubuntu.com/ubuntu-ports/pool/main/s/sqlite3/libsqlite3-dev_3.31.1-4_arm64.deb'

DEB_NAME = 'libsqlite3-dev_3.31.1-4_arm64.deb'

SRC_URI[md5sum] = "bff508af781c6519fdd456ae0b136a43"
