inherit deb-dl

LICENSE = "GPL-2.0+ & LGPL-2.1+ & BSD-3-clause & BSD-4-Clause & PD"

FULL_LINK = 'http://ports.ubuntu.com/ubuntu-ports/pool/main/u/util-linux/libblkid-dev_2.34-0.1ubuntu9_arm64.deb'

DEB_NAME = 'libblkid-dev_2.34-0.1ubuntu9_arm64.deb'

SRC_URI[md5sum] = "4ee6f9bd14c663156b11510f2f173838"
