inherit deb-dl

LICENSE = "LGPL-2.1+ & CCO-1.0 & GPL-2.0-with-Linux-syscall-note-exception & GPL-2.0+ & MIT"

FULL_LINK = 'http://ports.ubuntu.com/ubuntu-ports/pool/main/s/systemd/libsystemd-dev_245.4-4ubuntu3_arm64.deb'

DEB_NAME = 'libsystemd-dev_245.4-4ubuntu3_arm64.deb'

SRC_URI[md5sum] = "abe196acc033c16ea14546e777e02dfe"
