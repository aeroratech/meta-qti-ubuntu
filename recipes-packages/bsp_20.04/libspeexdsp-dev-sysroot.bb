inherit deb-dl

LICENSE = "BSD-3-Clause"

FULL_LINK = 'http://ports.ubuntu.com/ubuntu-ports/pool/main/s/speex/libspeexdsp-dev_1.2~rc1.2-1.1ubuntu1_arm64.deb'

DEB_NAME = 'libspeexdsp-dev_1.2~rc1.2-1.1ubuntu1_arm64.deb'

SRC_URI[md5sum] = "076924d87232df28a13ddbbf2c7f37a7"
