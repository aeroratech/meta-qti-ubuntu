inherit deb-dl

LICENSE = "LGPL-2.0+"

FULL_LINK = 'http://ports.ubuntu.com/ubuntu-ports/pool/main/libg/libgudev/libgudev-1.0-0_233-1_arm64.deb'

DEB_NAME = 'libgudev-1.0-0_233-1_arm64.deb'

SRC_URI[md5sum] = "696ef38cb44a3a0987243915ccd8f1fd"
