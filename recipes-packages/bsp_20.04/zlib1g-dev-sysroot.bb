inherit deb-dl

LICENSE = "Zlib"

FULL_LINK = 'http://ports.ubuntu.com/ubuntu-ports/pool/main/z/zlib/zlib1g-dev_1.2.11.dfsg-2ubuntu1_arm64.deb'

DEB_NAME = 'zlib1g-dev_1.2.11.dfsg-2ubuntu1_arm64.deb'

SRC_URI[md5sum] = "5c67a3b738f5a7d63cd6dcdca24391c3"
