inherit deb-dl

LICENSE = "LGPL-2.1+ & CCO-1.0 & GPL-2-with-Linux-syscall-note-exception & GPL-2.0+"

FULL_LINK = 'http://ports.ubuntu.com/ubuntu-ports/pool/main/s/systemd/udev_245.4-4ubuntu3_arm64.deb'

DEB_NAME = 'udev_245.4-4ubuntu3_arm64.deb'

SRC_URI[md5sum] = "fead5a9b49b8542e6fb712d71efec019"
