inherit deb-dl

LICENSE = "MIT"

FULL_LINK = 'http://ports.ubuntu.com/ubuntu-ports/pool/main/p/pixman/libpixman-1-dev_0.38.4-0ubuntu1_arm64.deb'

DEB_NAME = 'libpixman-1-dev_0.38.4-0ubuntu1_arm64.deb'

SRC_URI[md5sum] = "543c8e0b21f40a26a8d9c18a87649605"
