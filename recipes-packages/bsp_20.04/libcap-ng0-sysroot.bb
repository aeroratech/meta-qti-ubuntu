inherit deb-dl

LICENSE = "LGPL-2.1+"

FULL_LINK = 'http://ports.ubuntu.com/ubuntu-ports/pool/main/libc/libcap-ng/libcap-ng0_0.7.9-2.1build1_arm64.deb'

DEB_NAME = 'libcap-ng0_0.7.9-2.1build1_arm64.deb'

SRC_URI[md5sum] = "faeb3e0ffdd91f467951824e743096ae"
