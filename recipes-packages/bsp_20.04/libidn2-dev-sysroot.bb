inherit deb-dl

LICENSE = "GPL-3+ & LGPL-3.0+ | GPL-2.0+ & Unicode"

FULL_LINK = 'http://ports.ubuntu.com/ubuntu-ports/pool/main/libi/libidn2/libidn2-dev_2.2.0-2_arm64.deb'

DEB_NAME = 'libidn2-dev_2.2.0-2_arm64.deb'

SRC_URI[md5sum] = "f2879890217b209065f1efeca3985df5"
