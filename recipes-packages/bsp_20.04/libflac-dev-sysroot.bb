inherit deb-dl

LICENSE = "GFDL-1.1+ & BSD-3-Clause & GPL-2+ & LGPL-2.1+ & PD & ISC"

FULL_LINK = 'http://ports.ubuntu.com/ubuntu-ports/pool/main/f/flac/libflac-dev_1.3.3-1build1_arm64.deb'

DEB_NAME = 'libflac-dev_1.3.3-1build1_arm64.deb'

SRC_URI[md5sum] = "594cfdf96b90704ad342e43ab2328234"
