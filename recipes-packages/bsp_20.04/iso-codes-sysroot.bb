inherit deb-dl

LICENSE = "LGPL-2.1+"

FULL_LINK = 'http://ports.ubuntu.com/ubuntu-ports/pool/main/i/iso-codes/iso-codes_4.4-1_all.deb'

DEB_NAME = 'iso-codes_4.4-1_all.deb'

SRC_URI[md5sum] = "61b89768a199c297cd8f34da8415f7a5"
