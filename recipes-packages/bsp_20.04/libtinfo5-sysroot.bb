inherit deb-dl

LICENSE = "MIT-Style & BSD-3-Clause"

FULL_LINK = 'http://ports.ubuntu.com/ubuntu-ports/pool/universe/n/ncurses/libtinfo5_6.2-0ubuntu2_arm64.deb'

DEB_NAME = 'libtinfo5_6.2-0ubuntu2_arm64.deb'

SRC_URI[md5sum] = "83e259cf0c8d82aa4d06629149782b24"
