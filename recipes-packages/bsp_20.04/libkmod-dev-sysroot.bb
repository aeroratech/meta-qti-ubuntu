inherit deb-dl

LICENSE = "GPL-2.0+ & LGPL-2.1+"

FULL_LINK = 'http://ports.ubuntu.com/ubuntu-ports/pool/main/k/kmod/libkmod-dev_27-1ubuntu2_arm64.deb'

DEB_NAME = 'libkmod-dev_27-1ubuntu2_arm64.deb'

SRC_URI[md5sum] = "63ff2701038d8af8834c8b4e6cd74c48"
