inherit deb-dl

LICENSE = "GPL-2.0 & LGPL-2.1 & BSD-3-Clause"

FULL_LINK = 'http://ports.ubuntu.com/ubuntu-ports/pool/main/libn/libnl3/libnl-3-dev_3.4.0-1_arm64.deb'

DEB_NAME = 'libnl-3-dev_3.4.0-1_arm64.deb'

SRC_URI[md5sum] = "365309a5e05c429c70f9b03cc359b99e"
