inherit deb-dl

LICENSE = "curl & BSD-3-clause & ISC & BSD-4-Clause"

FULL_LINK = 'http://ports.ubuntu.com/ubuntu-ports/pool/main/c/curl/curl_7.68.0-1ubuntu2_arm64.deb'

DEB_NAME = 'curl_7.68.0-1ubuntu2_arm64.deb'

SRC_URI[md5sum] = "bcca1f1ae491a065f6f7b91fb3fd5ea7"
