inherit deb-dl

LICENSE = "BSD-3-clause"

FULL_LINK = 'http://ports.ubuntu.com/ubuntu-ports/pool/main/libb/libbsd/libbsd0_0.10.0-1_arm64.deb'

DEB_NAME = 'libbsd0_0.10.0-1_arm64.deb'

SRC_URI[md5sum] = "3603623835c0493328a1e5efaaa8dfbc"
