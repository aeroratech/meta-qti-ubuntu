inherit deb-dl

LICENSE = "BSD-3-clause & GPL-2.0+"

FULL_LINK = 'http://ports.ubuntu.com/ubuntu-ports/pool/main/h/heimdal/libasn1-8-heimdal_7.7.0+dfsg-1ubuntu1_arm64.deb'

DEB_NAME = 'libasn1-8-heimdal_7.7.0+dfsg-1ubuntu1_arm64.deb'

SRC_URI[md5sum] = "07f4c83d6678b912e01e38c1d7ea9ce7"
