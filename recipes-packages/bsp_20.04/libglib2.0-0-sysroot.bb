inherit deb-dl

LICENSE = "LGPL-2.0+ & MIT & GPL-2.0+"

FULL_LINK = 'http://ports.ubuntu.com/ubuntu-ports/pool/main/g/glib2.0/libglib2.0-0_2.64.2-1~fakesync1_arm64.deb'

DEB_NAME = 'libglib2.0-0_2.64.2-1~fakesync1_arm64.deb'

SRC_URI[md5sum] = "1e2d55c0d8a07a22b92c99c3a86cec13"
