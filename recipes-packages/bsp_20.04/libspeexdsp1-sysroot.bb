inherit deb-dl

LICENSE = "BSD-3-Clause"

FULL_LINK = 'http://ports.ubuntu.com/ubuntu-ports/pool/main/s/speex/libspeexdsp1_1.2~rc1.2-1.1ubuntu1_arm64.deb'

DEB_NAME = 'libspeexdsp1_1.2~rc1.2-1.1ubuntu1_arm64.deb'

SRC_URI[md5sum] = "cb2ee62a7f4f04a75a44521ad08110c6"
