inherit deb-dl

LICENSE = "OpenSSL & SSLeay"

FULL_LINK = 'http://ports.ubuntu.com/ubuntu-ports/pool/main/o/openssl/libssl1.1_1.1.1f-1ubuntu2_arm64.deb'

DEB_NAME = 'libssl1.1_1.1.1f-1ubuntu2_arm64.deb'

SRC_URI[md5sum] = "a038507108a3e8ee50853fedc2706c89"
