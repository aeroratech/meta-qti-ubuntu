inherit deb-dl

LICENSE = "OpenLDAP"

FULL_LINK = 'http://ports.ubuntu.com/ubuntu-ports/pool/main/o/openldap/libldap-2.4-2_2.4.49+dfsg-2ubuntu1_arm64.deb'

DEB_NAME = 'libldap-2.4-2_2.4.49+dfsg-2ubuntu1_arm64.deb'

SRC_URI[md5sum] = "bfb2e8e694c656d654b98656d6d2ecf3"
