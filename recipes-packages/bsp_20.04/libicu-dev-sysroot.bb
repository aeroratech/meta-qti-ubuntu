inherit deb-dl

LICENSE = "ICU & Unicode-DFS"

FULL_LINK = 'http://ports.ubuntu.com/ubuntu-ports/pool/main/i/icu/libicu-dev_66.1-2ubuntu2_arm64.deb'

DEB_NAME = 'libicu-dev_66.1-2ubuntu2_arm64.deb'

SRC_URI[md5sum] = "c59a1a1e0ebddb4bb18d4ad9513cb15a"
