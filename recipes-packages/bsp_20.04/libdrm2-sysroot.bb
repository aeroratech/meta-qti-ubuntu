inherit deb-dl

LICENSE = "MIT"

FULL_LINK = 'http://ports.ubuntu.com/ubuntu-ports/pool/main/libd/libdrm/libdrm2_2.4.101-2_arm64.deb'

DEB_NAME = 'libdrm2_2.4.101-2_arm64.deb'

SRC_URI[md5sum] = "4f0fc724eae7f8c65a77d5364795a188"
