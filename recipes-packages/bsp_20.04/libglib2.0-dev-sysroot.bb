inherit deb-dl

LICENSE = "LGPL-2.0+ & MIT & GPL-2.0+"

FULL_LINK = 'http://ports.ubuntu.com/ubuntu-ports/pool/main/g/glib2.0/libglib2.0-dev_2.64.2-1~fakesync1_arm64.deb'

DEB_NAME = 'libglib2.0-dev_2.64.2-1~fakesync1_arm64.deb'

SRC_URI[md5sum] = "01d216bbd4cf8a16ac5ab0df5fd9a8b7"
