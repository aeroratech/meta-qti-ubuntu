inherit deb-dl

LICENSE = "BSD-3-Clause"

FULL_LINK = 'http://ports.ubuntu.com/ubuntu-ports/pool/main/libv/libvorbis/libvorbisenc2_1.3.6-2ubuntu1_arm64.deb'

DEB_NAME = 'libvorbisenc2_1.3.6-2ubuntu1_arm64.deb'

SRC_URI[md5sum] = "796269c96505922d859df3841172e3e2"
