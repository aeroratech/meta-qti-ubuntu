inherit deb-dl

LICENSE = "curl & BSD-3-clause & ISC & BSD-4-Clause"

FULL_LINK = 'http://ports.ubuntu.com/ubuntu-ports/pool/main/c/curl/libcurl4_7.68.0-1ubuntu2_arm64.deb'

DEB_NAME = 'libcurl4_7.68.0-1ubuntu2_arm64.deb'

SRC_URI[md5sum] = "5b806ab6665ee46cca5f9f9ca14a4fa7"
