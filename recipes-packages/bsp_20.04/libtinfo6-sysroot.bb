inherit deb-dl

LICENSE = "MIT-Style & BSD-3-Clause"

FULL_LINK = 'http://ports.ubuntu.com/ubuntu-ports/pool/main/n/ncurses/libtinfo6_6.2-0ubuntu2_arm64.deb'

DEB_NAME = 'libtinfo6_6.2-0ubuntu2_arm64.deb'

SRC_URI[md5sum] = "4948feed76533621b3b84275f1595f59"
