inherit deb-dl

LICENSE = "MIT & BSD-3-Clause & more"

FULL_LINK = 'http://ports.ubuntu.com/ubuntu-ports/pool/main/k/krb5/libk5crypto3_1.17-6ubuntu4_arm64.deb'

DEB_NAME = 'libk5crypto3_1.17-6ubuntu4_arm64.deb'

SRC_URI[md5sum] = "6318718f89cbcf1000d63bf3002d4a00"
