inherit deb-dl

LICENSE = "MIT & ISC"

FULL_LINK = 'http://ports.ubuntu.com/ubuntu-ports/pool/main/libp/libpciaccess/libpciaccess-dev_0.16-0ubuntu1_arm64.deb'

DEB_NAME = 'libpciaccess-dev_0.16-0ubuntu1_arm64.deb'

SRC_URI[md5sum] = "399f5583f9dea97e96511402e5f99f96"
