inherit deb-dl

LICENSE = "GPL-2.0+ & LGPL-2.0+"

FULL_LINK = 'http://ports.ubuntu.com/ubuntu-ports/pool/main/s/sbc/libsbc1_1.4-1_arm64.deb'

DEB_NAME = 'libsbc1_1.4-1_arm64.deb'

SRC_URI[md5sum] = "949bc6771eea8a98adf662babee774b1"
