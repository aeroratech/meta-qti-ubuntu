inherit deb-dl

LICENSE = "MIT-Style"

FULL_LINK = 'http://ports.ubuntu.com/ubuntu-ports/pool/universe/x/xutils-dev/xutils-dev_7.7+5ubuntu2_arm64.deb'

DEB_NAME = 'xutils-dev_7.7+5ubuntu2_arm64.deb'

SRC_URI[md5sum] = "bfa738f4cc66fbcf9973816b7699d926"
