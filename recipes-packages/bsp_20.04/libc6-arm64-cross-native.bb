inherit native deb-dl

LICENSE = "EPL-1.0"

FULL_LINK = 'http://ports.ubuntu.com/ubuntu-ports/pool/main/c/cross-toolchain-base/libc6-arm64-cross_2.31-0ubuntu7cross1_all.deb'

DEB_NAME = 'libc6-arm64-cross_2.31-0ubuntu7cross1_all.deb'

SRC_URI[md5sum] = "faa39c8bc40fdd78c570f21e22331f93"
