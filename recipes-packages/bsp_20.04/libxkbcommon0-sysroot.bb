inherit deb-dl

LICENSE = "MIT-style"

FULL_LINK = 'http://ports.ubuntu.com/ubuntu-ports/pool/main/libx/libxkbcommon/libxkbcommon0_0.10.0-1_arm64.deb'

DEB_NAME = 'libxkbcommon0_0.10.0-1_arm64.deb'

SRC_URI[md5sum] = "ee3fb47cda03ac28702d90cdaf78d84d"
