inherit native deb-dl

LICENSE = "EPL-1.0"

FULL_LINK = 'http://ports.ubuntu.com/ubuntu-ports/pool/universe/g/gcc-10-cross/libgcc-10-dev-arm64-cross_10.3.0-1ubuntu1~20.04cross1_all.deb'

DEB_NAME = 'libgcc-10-dev-arm64-cross_10.3.0-1ubuntu1~20.04cross1_all.deb'

SRC_URI[md5sum] = "05c9381e886574eff8962322f911ab78"
