inherit deb-dl

LICENSE = "LGPL-2.1"

FULL_LINK = 'http://ports.ubuntu.com/ubuntu-ports/pool/main/m/mpg123/libout123-0_1.25.13-1_arm64.deb'

DEB_NAME = 'libout123-0_1.25.13-1_arm64.deb'

SRC_URI[md5sum] = "b0b79939a98991eae3819bfb9db2ac69"
