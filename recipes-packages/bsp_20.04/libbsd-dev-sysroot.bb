inherit deb-dl

LICENSE = "BSD-3-clause"

FULL_LINK = 'http://ports.ubuntu.com/ubuntu-ports/pool/main/libb/libbsd/libbsd-dev_0.10.0-1_arm64.deb'

DEB_NAME = 'libbsd-dev_0.10.0-1_arm64.deb'

SRC_URI[md5sum] = "365a3e633ecc4982d053a27cf55c34fb"
