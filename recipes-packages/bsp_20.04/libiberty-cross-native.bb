inherit native deb-dl

LICENSE = "GPL-3.0+ & GPL-2.0+ & LGPL-2.1+ & GFDL-1.3 & MIT & PD"

FULL_LINK = 'http://ports.ubuntu.com/ubuntu-ports/pool/main/libi/libiberty/libiberty-dev_20200409-1_arm64.deb'

DEB_NAME = 'libiberty-dev_20200409-1_arm64.deb'

SRC_URI[md5sum] = "7afc973eb1f8741c2d28d166905ff4d6"
