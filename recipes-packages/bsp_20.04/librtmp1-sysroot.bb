inherit deb-dl

LICENSE = "GPL-2.0+ & LGPL-2.1+"

FULL_LINK = 'http://ports.ubuntu.com/ubuntu-ports/pool/main/r/rtmpdump/librtmp1_2.4+20151223.gitfa8646d.1-2build1_arm64.deb'

DEB_NAME = 'librtmp1_2.4+20151223.gitfa8646d.1-2build1_arm64.deb'

SRC_URI[md5sum] = "1ae2894844d248d2b808b4e7c9489c7c"
