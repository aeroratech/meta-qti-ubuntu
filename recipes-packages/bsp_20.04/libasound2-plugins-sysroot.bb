inherit deb-dl

LICENSE = "LGPL-2.1+"

FULL_LINK = 'http://ports.ubuntu.com/ubuntu-ports/pool/main/a/alsa-plugins/libasound2-plugins_1.2.2-1ubuntu1_arm64.deb'

DEB_NAME = 'libasound2-plugins_1.2.2-1ubuntu1_arm64.deb'

SRC_URI[md5sum] = "653933a1fa2991da46ae3be958d2d500"
