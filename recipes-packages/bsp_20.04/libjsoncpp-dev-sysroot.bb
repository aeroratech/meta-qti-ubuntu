inherit deb-dl

LICENSE = "MIT | PD & GPL-3.0+"

FULL_LINK = 'http://ports.ubuntu.com/ubuntu-ports/pool/main/libj/libjsoncpp/libjsoncpp-dev_1.7.4-3.1ubuntu2_arm64.deb'

DEB_NAME = 'libjsoncpp-dev_1.7.4-3.1ubuntu2_arm64.deb'

SRC_URI[md5sum] = "5306f8d7d03e0920442b88dd672a3c80"
