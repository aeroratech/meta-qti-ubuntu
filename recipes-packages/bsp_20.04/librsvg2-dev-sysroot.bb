inherit deb-dl

LICENSE = "LGPL-2.0+"

FULL_LINK = 'http://ports.ubuntu.com/ubuntu-ports/pool/main/libr/librsvg/librsvg2-dev_2.48.2-1_arm64.deb'

DEB_NAME = 'librsvg2-dev_2.48.2-1_arm64.deb'

SRC_URI[md5sum] = "2195a938720ca8e9e2bef0c498ca26b0"
