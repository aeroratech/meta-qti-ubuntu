inherit deb-dl

LICENSE = "IJG & LGPL-2.1"

FULL_LINK = 'http://ports.ubuntu.com/ubuntu-ports/pool/main/libj/libjpeg-turbo/libjpeg-turbo8-dev_2.0.3-0ubuntu1_arm64.deb'

DEB_NAME = 'libjpeg-turbo8-dev_2.0.3-0ubuntu1_arm64.deb'

SRC_URI[md5sum] = "0b57412a377fae33d07eb820fb877bd0"
