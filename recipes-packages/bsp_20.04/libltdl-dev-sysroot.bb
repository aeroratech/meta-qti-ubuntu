inherit deb-dl

LICENSE = "GPL-2.0+ & GFDL-1.3+"

FULL_LINK = 'http://ports.ubuntu.com/ubuntu-ports/pool/main/libt/libtool/libltdl-dev_2.4.6-14_arm64.deb'

DEB_NAME = 'libltdl-dev_2.4.6-14_arm64.deb'

SRC_URI[md5sum] = "946f5a7c5687559a073548960105dedd"
