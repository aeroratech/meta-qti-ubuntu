inherit deb-dl

LICENSE = "BSD-3-Clause & GPL-2.0 & more"

#LIC_FILES_CHKSUM = "\
#    file://https://changelogs.ubuntu.com/changelogs/pool/main/s/shadow/shadow_4.8.1-1ubuntu5/copyright;md5=4b6b514ee926d7b7f09355cb7fc2e312 \
#"

FULL_LINK = 'http://ports.ubuntu.com/ubuntu-ports/pool/main/s/shadow/login_4.8.1-1ubuntu5_arm64.deb'

DEB_NAME = 'login_4.8.1-1ubuntu5_arm64.deb'

SRC_URI[md5sum] = "5dec7dceae0785240d7b2af3d4b9689d"
