inherit deb-dl

LICENSE = "GPL-2.0"

FULL_LINK = 'http://ports.ubuntu.com/ubuntu-ports/pool/main/l/linux/linux-libc-dev_5.4.0-26.30_arm64.deb'

DEB_NAME = 'linux-libc-dev_5.4.0-26.30_arm64.deb'

SRC_URI[md5sum] = "60c39647497d89ffefd602faade68988"
