inherit deb-dl

LICENSE = "LGPL-2.1+ & GPL-3.0+ & GFDL-1.3+"

FULL_LINK = 'http://ports.ubuntu.com/ubuntu-ports/pool/main/libt/libtasn1-6/libtasn1-6_4.16.0-2_arm64.deb'

DEB_NAME = 'libtasn1-6_4.16.0-2_arm64.deb'

SRC_URI[md5sum] = "51c13005f6e7d32cc6b935fc1b8a327b"
