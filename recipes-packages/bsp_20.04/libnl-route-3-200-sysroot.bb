inherit deb-dl

LICENSE = "GPL-2.0 & LGPL-2.1 & BSD-3-Clause"

FULL_LINK = 'http://ports.ubuntu.com/ubuntu-ports/pool/main/libn/libnl3/libnl-route-3-200_3.4.0-1_arm64.deb'

DEB_NAME = 'libnl-route-3-200_3.4.0-1_arm64.deb'

SRC_URI[md5sum] = "0d20116656fc6fe161d4b81a4641aa60"
