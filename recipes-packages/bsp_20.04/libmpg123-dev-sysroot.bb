inherit deb-dl

LICENSE = "LGPL-2.1"

FULL_LINK = 'http://ports.ubuntu.com/ubuntu-ports/pool/main/m/mpg123/libmpg123-dev_1.25.13-1_arm64.deb'

DEB_NAME = 'libmpg123-dev_1.25.13-1_arm64.deb'

SRC_URI[md5sum] = "8b7e4a422e5f27f28550545e3b79b30d"
