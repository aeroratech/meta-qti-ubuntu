inherit deb-dl

LICENSE = "FTL | GPL-2.0+"

FULL_LINK = 'http://ports.ubuntu.com/ubuntu-ports/pool/main/f/freetype/libfreetype-dev_2.10.1-2_arm64.deb'

DEB_NAME = 'libfreetype-dev_2.10.1-2_arm64.deb'

SRC_URI[md5sum] = "cde1fce8d0242e6d0bf41f7504319107"
