inherit deb-dl

LICENSE = "MIT"

FULL_LINK = 'http://ports.ubuntu.com/ubuntu-ports/pool/main/m/mtdev/libmtdev1_1.1.5-1.1_arm64.deb'

DEB_NAME = 'libmtdev1_1.1.5-1.1_arm64.deb'

SRC_URI[md5sum] = "20e25721223a2fe03203a83bc881853e"
