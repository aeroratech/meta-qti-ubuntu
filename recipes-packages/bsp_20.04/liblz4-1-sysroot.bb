inherit deb-dl

LICENSE = "BSD-2-clause & GPL-2.0+"

FULL_LINK = 'http://ports.ubuntu.com/ubuntu-ports/pool/main/l/lz4/liblz4-1_1.9.2-2_arm64.deb'

DEB_NAME = 'liblz4-1_1.9.2-2_arm64.deb'

SRC_URI[md5sum] = "576cfe6b63d00b11b5db2f9555923ed7"
