inherit deb-dl

LICENSE = "BSD-3-Clause & GPL-2.0+"

FULL_LINK = 'http://ports.ubuntu.com/ubuntu-ports/pool/main/h/heimdal/libhx509-5-heimdal_7.7.0+dfsg-1ubuntu1_arm64.deb'

DEB_NAME = 'libhx509-5-heimdal_7.7.0+dfsg-1ubuntu1_arm64.deb'

SRC_URI[md5sum] = "612079627ce8dda6d33bf5d13bbeb4d2"
