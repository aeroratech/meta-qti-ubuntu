inherit deb-dl

LICENSE = "LGPL-2.0+"

FULL_LINK = 'http://ports.ubuntu.com/ubuntu-ports/pool/main/libg/libgudev/libgudev-1.0-dev_233-1_arm64.deb'

DEB_NAME = 'libgudev-1.0-dev_233-1_arm64.deb'

SRC_URI[md5sum] = "33d2ccde828ef425ace76ada722c8339"
