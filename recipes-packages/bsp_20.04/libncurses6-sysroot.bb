inherit deb-dl

LICENSE = "MIT-Style & BSD-3-Clause"

FULL_LINK = 'http://ports.ubuntu.com/ubuntu-ports/pool/main/n/ncurses/libncurses6_6.2-0ubuntu2_arm64.deb'

DEB_NAME = 'libncurses6_6.2-0ubuntu2_arm64.deb'

SRC_URI[md5sum] = "c6e05748821ea976283c8018a199433a"
