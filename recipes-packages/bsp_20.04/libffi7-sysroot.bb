inherit deb-dl

LICENSE = "MIT & GPL-2.0+"

FULL_LINK = 'http://ports.ubuntu.com/ubuntu-ports/pool/main/libf/libffi/libffi7_3.3-4_arm64.deb'

DEB_NAME = 'libffi7_3.3-4_arm64.deb'

SRC_URI[md5sum] = "eae849d100aadd84a3ebee069b63acda"
