inherit native deb-dl

LICENSE = "EPL-1.0"

FULL_LINK = 'http://ports.ubuntu.com/ubuntu-ports/pool/universe/g/gcc-10-cross/libstdc++-10-dev-arm64-cross_10.3.0-1ubuntu1~20.04cross1_all.deb'

DEB_NAME = 'libstdc++-10-dev-arm64-cross_10.3.0-1ubuntu1~20.04cross1_all.deb'

SRC_URI[md5sum] = "8b9ee4dd04b8ecb92899266d6a2e935b"
