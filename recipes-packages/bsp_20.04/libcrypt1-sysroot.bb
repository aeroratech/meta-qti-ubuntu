inherit deb-dl

LICENSE = "LGPL-2.1+"

FULL_LINK = 'http://ports.ubuntu.com/ubuntu-ports/pool/main/libx/libxcrypt/libcrypt1_4.4.10-10ubuntu4_arm64.deb'

DEB_NAME = 'libcrypt1_4.4.10-10ubuntu4_arm64.deb'

SRC_URI[md5sum] = "41ffe3deba96b6a616667ecf455b42ec"
