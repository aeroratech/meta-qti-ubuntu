inherit deb-dl

LICENSE = "PD & GPL-2.0 & LGPL-2.1+"

FULL_LINK = 'http://ports.ubuntu.com/ubuntu-ports/pool/main/libs/libselinux/libselinux1_3.0-1build2_arm64.deb'

DEB_NAME = 'libselinux1_3.0-1build2_arm64.deb'

SRC_URI[md5sum] = "27f6b805e67028b00a012663edfa198f"
