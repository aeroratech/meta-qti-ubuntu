inherit native deb-dl

LICENSE = "BSD-variant"

FULL_LINK = 'http://ports.ubuntu.com/ubuntu-ports/pool/main/b/bzip2/libbz2-dev_1.0.8-2_arm64.deb'

DEB_NAME = 'libbz2-dev_1.0.8-2_arm64.deb'

SRC_URI[md5sum] = "239228b4f3ce6b3f6d929445df491380"
