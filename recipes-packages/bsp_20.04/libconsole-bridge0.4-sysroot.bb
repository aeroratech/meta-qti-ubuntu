inherit deb-dl

LICENSE = "BSD-3-Clause"

FULL_LINK = 'http://ports.ubuntu.com/ubuntu-ports/pool/universe/c/console-bridge/libconsole-bridge0.4_0.4.4+dfsg-1build1_arm64.deb'

DEB_NAME = 'libconsole-bridge0.4_0.4.4+dfsg-1build1_arm64.deb'

SRC_URI[md5sum] = "1536fd5e0cbcbe916b48290a9b7506a0"
