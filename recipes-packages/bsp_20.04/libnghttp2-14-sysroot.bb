inherit deb-dl

LICENSE = "MIT & BSD-2-clause & OFL-1.1"

FULL_LINK = 'http://ports.ubuntu.com/ubuntu-ports/pool/main/n/nghttp2/libnghttp2-14_1.40.0-1build1_arm64.deb'

DEB_NAME = 'libnghttp2-14_1.40.0-1build1_arm64.deb'

SRC_URI[md5sum] = "485b152334f0fc07b8288027427781f4"
