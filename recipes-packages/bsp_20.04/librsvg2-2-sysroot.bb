inherit deb-dl

LICENSE = "LGPL-2.0+"

FULL_LINK = 'http://ports.ubuntu.com/ubuntu-ports/pool/main/libr/librsvg/librsvg2-2_2.48.2-1_arm64.deb'

DEB_NAME = 'librsvg2-2_2.48.2-1_arm64.deb'

SRC_URI[md5sum] = "31006729e4f9e5a7b104a91110c65583"
