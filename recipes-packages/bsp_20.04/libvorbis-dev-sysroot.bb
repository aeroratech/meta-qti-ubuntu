inherit deb-dl

LICENSE = "BSD-3-Clause"

FULL_LINK = 'http://ports.ubuntu.com/ubuntu-ports/pool/main/libv/libvorbis/libvorbis-dev_1.3.6-2ubuntu1_arm64.deb'

DEB_NAME = 'libvorbis-dev_1.3.6-2ubuntu1_arm64.deb'

SRC_URI[md5sum] = "13e1288ac8be64eb1e3b38fdeb01c687"
