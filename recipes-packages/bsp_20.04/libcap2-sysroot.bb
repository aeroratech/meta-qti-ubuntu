inherit deb-dl

LICENSE = "BSD-3-clause | GPL-2.0"

FULL_LINK = 'http://ports.ubuntu.com/ubuntu-ports/pool/main/libc/libcap2/libcap2_2.32-1_arm64.deb'

DEB_NAME = 'libcap2_2.32-1_arm64.deb'

SRC_URI[md5sum] = "b2b63c58c7729aef011ca9be196c58c1"
