inherit deb-dl

LICENSE = "LGPL-2.1"

FULL_LINK = 'http://ports.ubuntu.com/ubuntu-ports/pool/main/m/mpg123/libmpg123-0_1.25.13-1_arm64.deb'

DEB_NAME = 'libmpg123-0_1.25.13-1_arm64.deb'

SRC_URI[md5sum] = "4d9ec0124dd25aa4ebed62d918986792"
