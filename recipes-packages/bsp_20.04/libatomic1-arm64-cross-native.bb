inherit native deb-dl

LICENSE = " EPL-1.0"

FULL_LINK = 'http://ports.ubuntu.com/ubuntu-ports/pool/main/g/gcc-10-cross/libatomic1-arm64-cross_10.3.0-1ubuntu1~20.04cross1_all.deb'

DEB_NAME = 'libatomic1-arm64-cross_10.3.0-1ubuntu1~20.04cross1_all.deb'

SRC_URI[md5sum] = "2ba80c30506c0a71c4616ae874d15890"
