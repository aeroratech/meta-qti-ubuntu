inherit native deb-dl

LICENSE = " GPL-3.0+ | GPL-2.0+"

FULL_LINK = 'http://ports.ubuntu.com/ubuntu-ports/pool/main/e/elfutils/libelf-dev_0.176-1.1build1_arm64.deb'

DEB_NAME = 'libelf-dev_0.176-1.1build1_arm64.deb'

SRC_URI[md5sum] = "79ea1e6471975fe07a19c59c7217adfa"
