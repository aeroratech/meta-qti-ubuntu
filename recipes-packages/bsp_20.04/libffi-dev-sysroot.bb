inherit deb-dl

LICENSE = "MIT & GPL-2.0+"

FULL_LINK = 'http://ports.ubuntu.com/ubuntu-ports/pool/main/libf/libffi/libffi-dev_3.3-4_arm64.deb'

DEB_NAME = 'libffi-dev_3.3-4_arm64.deb'

SRC_URI[md5sum] = "d0e053bdfdaa35c8a2cd61cb2cd66ffa"
