inherit deb-dl

LICENSE = "LGPL-2.1+ & GPL-3.0+"

FULL_LINK = 'http://ports.ubuntu.com/ubuntu-ports/pool/main/libg/libgpg-error/libgpg-error0_1.37-1_arm64.deb'

DEB_NAME = 'libgpg-error0_1.37-1_arm64.deb'

SRC_URI[md5sum] = "5bcfb76578115c3ca120ae4286533900"
