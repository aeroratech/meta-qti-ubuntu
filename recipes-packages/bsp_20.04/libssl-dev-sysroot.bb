inherit deb-dl

LICENSE = "OpenSSL & SSLeay"

FULL_LINK = 'http://ports.ubuntu.com/ubuntu-ports/pool/main/o/openssl/libssl-dev_1.1.1f-1ubuntu2_arm64.deb'

DEB_NAME = 'libssl-dev_1.1.1f-1ubuntu2_arm64.deb'

SRC_URI[md5sum] = "d695f6e53803f913e8d356dd6b49e2f3"
