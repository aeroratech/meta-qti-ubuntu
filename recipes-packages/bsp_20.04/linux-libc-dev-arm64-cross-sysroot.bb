inherit native deb-dl

LICENSE = "EPL-1.0 & GPL-2.0"

FULL_LINK = 'http://ports.ubuntu.com/ubuntu-ports/pool/main/c/cross-toolchain-base/linux-libc-dev-arm64-cross_5.4.0-21.25cross1_all.deb'

DEB_NAME = 'linux-libc-dev-arm64-cross_5.4.0-21.25cross1_all.deb'

SRC_URI[md5sum] = "b47be11ecae7e512243fe2413ce0a6a9"
