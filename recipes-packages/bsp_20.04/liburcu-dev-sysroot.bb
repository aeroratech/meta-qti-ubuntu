inherit deb-dl

LICENSE = "LGPL-2.1+ & GPL-3.0+ & MIT & GPL-2.0+"

FULL_LINK = 'http://ports.ubuntu.com/ubuntu-ports/pool/main/libu/liburcu/liburcu-dev_0.11.1-2_arm64.deb'

DEB_NAME = 'liburcu-dev_0.11.1-2_arm64.deb'

SRC_URI[md5sum] = "7afc44a891fc77c315000c330f6352f0"
