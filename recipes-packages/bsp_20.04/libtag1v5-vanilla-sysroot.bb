inherit deb-dl

LICENSE = "LGPL-2.1 | MPL-1.1 & BSD-2-clause"

FULL_LINK = 'http://ports.ubuntu.com/ubuntu-ports/pool/main/t/taglib/libtag1v5-vanilla_1.11.1+dfsg.1-0.3ubuntu2_arm64.deb'

DEB_NAME = 'libtag1v5-vanilla_1.11.1+dfsg.1-0.3ubuntu2_arm64.deb'

SRC_URI[md5sum] = "8a08f5f77aa4538bef67f06e24831b8c"
