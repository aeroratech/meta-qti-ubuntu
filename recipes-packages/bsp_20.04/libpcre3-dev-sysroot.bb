inherit deb-dl

LICENSE = "BSD-3-Clause"

FULL_LINK = 'http://ports.ubuntu.com/ubuntu-ports/pool/main/p/pcre3/libpcre3-dev_8.39-12build1_arm64.deb'

DEB_NAME = 'libpcre3-dev_8.39-12build1_arm64.deb'

SRC_URI[md5sum] = "5b1ecbd87094ef5ac19a79c9ce41bd8f"
