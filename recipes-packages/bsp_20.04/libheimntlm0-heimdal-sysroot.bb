inherit deb-dl

LICENSE = "BSD-3-Clause & GPL-2.0+"

FULL_LINK = 'http://ports.ubuntu.com/ubuntu-ports/pool/main/h/heimdal/libheimntlm0-heimdal_7.7.0+dfsg-1ubuntu1_arm64.deb'

DEB_NAME = 'libheimntlm0-heimdal_7.7.0+dfsg-1ubuntu1_arm64.deb'

SRC_URI[md5sum] = "02439220c549e7fcdba43b4ba7185d79"
