inherit deb-dl

LICENSE = "BSL-1.0 & PD"

FULL_LINK = 'http://ports.ubuntu.com/ubuntu-ports/pool/universe/libc/libcrypto++/libcrypto++-dev_5.6.4-9build1_arm64.deb'

DEB_NAME = 'libcrypto++-dev_5.6.4-9build1_arm64.deb'

SRC_URI[md5sum] = "b4443ee1267965e98f3d526528af7c46"
