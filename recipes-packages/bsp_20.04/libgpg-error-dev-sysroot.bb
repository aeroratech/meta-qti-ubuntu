inherit deb-dl

LICENSE = "LGPL-2.1+ & GPL-3.0+"

FULL_LINK = 'http://ports.ubuntu.com/ubuntu-ports/pool/main/libg/libgpg-error/libgpg-error-dev_1.37-1_arm64.deb'

DEB_NAME = 'libgpg-error-dev_1.37-1_arm64.deb'

SRC_URI[md5sum] = "91793d0150ad80c1d9c7dd431a1d847e"
