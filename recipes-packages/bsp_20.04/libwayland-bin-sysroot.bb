inherit deb-dl

LICENSE = "X11"

FULL_LINK = 'http://ports.ubuntu.com/ubuntu-ports/pool/main/w/wayland/libwayland-bin_1.18.0-1_arm64.deb'

DEB_NAME = 'libwayland-bin_1.18.0-1_arm64.deb'

SRC_URI[md5sum] = "131b8959d9df15fb01f903d32423be05"
