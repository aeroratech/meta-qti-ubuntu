inherit deb-dl

LICENSE = "LGPL-2.1+-with-openssl-exception"

FULL_LINK = 'http://ports.ubuntu.com/ubuntu-ports/pool/main/libs/libssh/libssh-4_0.9.3-2ubuntu2_arm64.deb'

DEB_NAME = 'libssh-4_0.9.3-2ubuntu2_arm64.deb'

SRC_URI[md5sum] = "8623cd32c731056539859089ab1fb683"
