inherit deb-dl

LICENSE = "LGPL-2.1+ & GPL-2.0+"

FULL_LINK = 'http://ports.ubuntu.com/ubuntu-ports/pool/main/n/nettle/libhogweed5_3.5.1+really3.5.1-2_arm64.deb'

DEB_NAME = 'libhogweed5_3.5.1+really3.5.1-2_arm64.deb'

SRC_URI[md5sum] = "462c9c0f20619873239e03059a5e9d5d"
