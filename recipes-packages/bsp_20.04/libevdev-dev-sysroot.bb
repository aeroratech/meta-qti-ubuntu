inherit deb-dl

LICENSE = "X11 & MIT & GPL-2.0+ & Apache-2.0 & BSD-3-Clause"

FULL_LINK = 'http://ports.ubuntu.com/ubuntu-ports/pool/main/libe/libevdev/libevdev-dev_1.9.0+dfsg-1_arm64.deb'

DEB_NAME = 'libevdev-dev_1.9.0+dfsg-1_arm64.deb'

SRC_URI[md5sum] = "1db02ed1b82d6008170ba0e1de13cd1b"
