inherit deb-dl

LICENSE = "ICU & Unicode-DFS"

FULL_LINK = 'http://ports.ubuntu.com/ubuntu-ports/pool/main/i/icu/libicu66_66.1-2ubuntu2_arm64.deb'

DEB_NAME = 'libicu66_66.1-2ubuntu2_arm64.deb'

SRC_URI[md5sum] = "2cd9228d607e0bad4caacd0cf8eac86e"
