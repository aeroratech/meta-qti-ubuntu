inherit deb-dl

LICENSE = "libpng"

FULL_LINK = 'http://ports.ubuntu.com/ubuntu-ports/pool/main/libp/libpng1.6/libpng-dev_1.6.37-2_arm64.deb'

DEB_NAME = 'libpng-dev_1.6.37-2_arm64.deb'

SRC_URI[md5sum] = "05d3dc4ceeee1a4893a5afb268cff79e"
