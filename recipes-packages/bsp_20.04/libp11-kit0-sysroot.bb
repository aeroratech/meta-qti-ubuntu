inherit deb-dl

LICENSE = "BSD-3-Clause"

FULL_LINK = 'http://ports.ubuntu.com/ubuntu-ports/pool/main/p/p11-kit/libp11-kit0_0.23.20-1build1_arm64.deb'

DEB_NAME = 'libp11-kit0_0.23.20-1build1_arm64.deb'

SRC_URI[md5sum] = "1ebb9e3c5e513a2c29f349e8dc2a9a0c"
