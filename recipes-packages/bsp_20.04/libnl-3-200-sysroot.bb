inherit deb-dl

LICENSE = "GPL-2.0 & LGPL-2.1 & BSD-3-Clause"

FULL_LINK = 'http://ports.ubuntu.com/ubuntu-ports/pool/main/libn/libnl3/libnl-3-200_3.4.0-1_arm64.deb'

DEB_NAME = 'libnl-3-200_3.4.0-1_arm64.deb'

SRC_URI[md5sum] = "f714ea0df4d60d649c1ad90763b3279e"
