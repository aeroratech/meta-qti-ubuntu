inherit deb-dl

LICENSE = "LGPL-2.0+"

FULL_LINK = 'http://ports.ubuntu.com/ubuntu-ports/pool/main/libc/libcroco/libcroco3-dev_0.6.13-1_arm64.deb'

DEB_NAME = 'libcroco3-dev_0.6.13-1_arm64.deb'

SRC_URI[md5sum] = "494f2d09a4f136de4a18a6fb3c86e7e3"
