inherit deb-dl

LICENSE = "BSD-2-clause & GPL-2.0"

FULL_LINK = 'http://ports.ubuntu.com/ubuntu-ports/pool/main/libs/libsamplerate/libsamplerate0_0.1.9-2_arm64.deb'

DEB_NAME = 'libsamplerate0_0.1.9-2_arm64.deb'

SRC_URI[md5sum] = "9acaacc4460560d52b2480617fbb662e"
