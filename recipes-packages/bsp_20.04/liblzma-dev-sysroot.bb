inherit deb-dl

LICENSE = "LGPL-2.1+ & GPL-2.0+ & GPL-3.0+ & PD"

FULL_LINK = 'http://ports.ubuntu.com/ubuntu-ports/pool/main/x/xz-utils/liblzma-dev_5.2.4-1_arm64.deb'

DEB_NAME = 'liblzma-dev_5.2.4-1_arm64.deb'

SRC_URI[md5sum] = "ff5f84f3c09ea6dc1c717aaf51f8bb43"
