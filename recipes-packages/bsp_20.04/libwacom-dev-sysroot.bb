inherit deb-dl

LICENSE = "MIT"

FULL_LINK = 'http://ports.ubuntu.com/ubuntu-ports/pool/main/libw/libwacom/libwacom-dev_1.3-2ubuntu1_arm64.deb'

DEB_NAME = 'libwacom-dev_1.3-2ubuntu1_arm64.deb'

SRC_URI[md5sum] = "bfbc50e917f2b30072873e312cb93184"
