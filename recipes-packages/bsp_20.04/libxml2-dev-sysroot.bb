inherit deb-dl

LICENSE = "MIT-Style & ISC"

FULL_LINK = 'http://ports.ubuntu.com/ubuntu-ports/pool/main/libx/libxml2/libxml2-dev_2.9.10+dfsg-5_arm64.deb'

DEB_NAME = 'libxml2-dev_2.9.10+dfsg-5_arm64.deb'

SRC_URI[md5sum] = "732d52953a1d846919bdbf1330e58ed3"
