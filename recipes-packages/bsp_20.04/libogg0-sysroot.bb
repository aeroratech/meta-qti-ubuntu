inherit deb-dl

LICENSE = "BSD-3-Clause"

FULL_LINK = 'http://ports.ubuntu.com/ubuntu-ports/pool/main/libo/libogg/libogg0_1.3.4-0ubuntu1_arm64.deb'

DEB_NAME = 'libogg0_1.3.4-0ubuntu1_arm64.deb'

SRC_URI[md5sum] = "ac559450229ee7b2fde042b63a2b8dc7"
