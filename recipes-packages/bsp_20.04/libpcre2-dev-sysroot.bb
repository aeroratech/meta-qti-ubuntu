inherit deb-dl

LICENSE = "BSD-3-Clause"

FULL_LINK = 'http://ports.ubuntu.com/ubuntu-ports/pool/main/p/pcre2/libpcre2-dev_10.34-7_arm64.deb'

DEB_NAME = 'libpcre2-dev_10.34-7_arm64.deb'

SRC_URI[md5sum] = "0aa6f2862768ab08fbf3c27d3c600998"
