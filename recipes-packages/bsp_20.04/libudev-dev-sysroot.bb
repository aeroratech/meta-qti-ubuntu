inherit deb-dl

LICENSE = "LGPL-2.1+ & CCO-1.0 & GPL-2.0+ & GPL-2.0-with-Linux-syscall-note-exception & MIT & PD"

FULL_LINK = 'http://ports.ubuntu.com/ubuntu-ports/pool/main/s/systemd/libudev-dev_245.4-4ubuntu3_arm64.deb'

DEB_NAME = 'libudev-dev_245.4-4ubuntu3_arm64.deb'

SRC_URI[md5sum] = "ee33dd33ded669175f38dc0c5819eb21"
