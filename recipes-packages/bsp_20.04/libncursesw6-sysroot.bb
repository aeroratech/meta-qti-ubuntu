inherit deb-dl

LICENSE = "MIT-Style & BSD-3-Clause"

FULL_LINK = 'http://ports.ubuntu.com/ubuntu-ports/pool/main/n/ncurses/libncursesw6_6.2-0ubuntu2_arm64.deb'

DEB_NAME = 'libncursesw6_6.2-0ubuntu2_arm64.deb'

SRC_URI[md5sum] = "e623276621c0e4f11b3ea9071d1a10c5"
