inherit deb-dl

LICENSE = "GPL-2.0+"

FULL_LINK = 'http://ports.ubuntu.com/ubuntu-ports/pool/main/u/util-linux/libmount1_2.34-0.1ubuntu9_arm64.deb'

DEB_NAME = 'libmount1_2.34-0.1ubuntu9_arm64.deb'

SRC_URI[md5sum] = "c7247215eb6d41a5987f383c2b933a7e"
