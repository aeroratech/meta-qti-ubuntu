inherit deb-dl

LICENSE = "BSD-3-Clause"

FULL_LINK = 'http://ports.ubuntu.com/ubuntu-ports/pool/main/p/pcre2/libpcre2-8-0_10.34-7_arm64.deb'

DEB_NAME = 'libpcre2-8-0_10.34-7_arm64.deb'

SRC_URI[md5sum] = "3b654c6c3e623b1b67c557622efaee3c"
