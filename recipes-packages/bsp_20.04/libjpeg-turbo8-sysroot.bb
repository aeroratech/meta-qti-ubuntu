inherit deb-dl

LICENSE = "IJG & LGPL-2.1"

FULL_LINK = 'http://ports.ubuntu.com/ubuntu-ports/pool/main/libj/libjpeg-turbo/libjpeg-turbo8_2.0.3-0ubuntu1_arm64.deb'

DEB_NAME = 'libjpeg-turbo8_2.0.3-0ubuntu1_arm64.deb'

SRC_URI[md5sum] = "d9b861903491caa94ff8ea88220b9bf9"
