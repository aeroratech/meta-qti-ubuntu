inherit deb-dl

LICENSE = "LGPL-2.1+"

FULL_LINK = 'http://ports.ubuntu.com/ubuntu-ports/pool/main/libs/libsndfile/libsndfile1-dev_1.0.28-7_arm64.deb'

DEB_NAME = 'libsndfile1-dev_1.0.28-7_arm64.deb'

SRC_URI[md5sum] = "55412d2642906125ee588a13bf01cace"
