inherit deb-dl

LICENSE = "BSD-3-clause & GPL-2.0+"

FULL_LINK = 'http://ports.ubuntu.com/ubuntu-ports/pool/main/i/init-system-helpers/init-system-helpers_1.57_all.deb'

DEB_NAME = 'init-system-helpers_1.57_all.deb'

SRC_URI[md5sum] = "6bb7bbd31d00dfab8eeee9d4dc021514"
