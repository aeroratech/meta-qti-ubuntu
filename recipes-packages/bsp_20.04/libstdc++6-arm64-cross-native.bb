inherit native deb-dl

LICENSE = "EPL-1.0"

FULL_LINK = 'http://ports.ubuntu.com/ubuntu-ports/pool/main/g/gcc-10-cross/libstdc++6-arm64-cross_10.3.0-1ubuntu1~20.04cross1_all.deb'

DEB_NAME = 'libstdc++6-arm64-cross_10.3.0-1ubuntu1~20.04cross1_all.deb'

SRC_URI[md5sum] = "ae7c080b8c2130d800aa15b060c32578"
