inherit deb-dl

LICENSE = "BSD-3-Clause"

FULL_LINK = 'http://ports.ubuntu.com/ubuntu-ports/pool/universe/c/console-bridge/libconsole-bridge-dev_0.4.4+dfsg-1build1_arm64.deb'

DEB_NAME = 'libconsole-bridge-dev_0.4.4+dfsg-1build1_arm64.deb'

SRC_URI[md5sum] = "457231419968dde5e43fb65841458588"
