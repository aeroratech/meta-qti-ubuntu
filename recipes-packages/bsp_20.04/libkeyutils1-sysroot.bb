inherit deb-dl

LICENSE = "GPL-2.0+ & LGPL-2.0+"

FULL_LINK = 'http://ports.ubuntu.com/ubuntu-ports/pool/main/k/keyutils/libkeyutils1_1.6-6ubuntu1_arm64.deb'

DEB_NAME = 'libkeyutils1_1.6-6ubuntu1_arm64.deb'

SRC_URI[md5sum] = "7dd0ba4b8994f1c17993878244185de4"
