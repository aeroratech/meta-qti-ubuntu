inherit deb-dl

LICENSE = "LGPL-3.0+ & GPL-2.0+"

FULL_LINK = 'http://ports.ubuntu.com/ubuntu-ports/pool/main/g/gmp/libgmp10_6.2.0+dfsg-4_arm64.deb'

DEB_NAME = 'libgmp10_6.2.0+dfsg-4_arm64.deb'

SRC_URI[md5sum] = "58f7fae1af1a46074d0f429bbfec57ab"
