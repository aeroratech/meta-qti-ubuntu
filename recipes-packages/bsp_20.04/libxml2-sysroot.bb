inherit deb-dl

LICENSE = "MIT-Style & ISC"

FULL_LINK = 'http://ports.ubuntu.com/ubuntu-ports/pool/main/libx/libxml2/libxml2_2.9.10+dfsg-5_arm64.deb'

DEB_NAME = 'libxml2_2.9.10+dfsg-5_arm64.deb'

SRC_URI[md5sum] = "ba30849b81596b430b9fc4b73d8b1820"
