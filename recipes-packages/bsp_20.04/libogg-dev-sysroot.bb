inherit deb-dl

LICENSE = "BSD-3-Clause"

FULL_LINK = 'http://ports.ubuntu.com/ubuntu-ports/pool/main/libo/libogg/libogg-dev_1.3.4-0ubuntu1_arm64.deb'

DEB_NAME = 'libogg-dev_1.3.4-0ubuntu1_arm64.deb'

SRC_URI[md5sum] = "ddcab26bc4a6e4fc89b60c416caf9683"
