inherit deb-dl

LICENSE = "GPL-2.0+"

FULL_LINK = 'http://ports.ubuntu.com/ubuntu-ports/pool/main/u/util-linux/uuid-dev_2.34-0.1ubuntu9_arm64.deb'

DEB_NAME = 'uuid-dev_2.34-0.1ubuntu9_arm64.deb'

SRC_URI[md5sum] = "3b9a2dab4d6aca9c33b5c411a84190f8"
