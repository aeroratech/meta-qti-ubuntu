inherit deb-dl

LICENSE = "BSD-3-clause & GPL-2.0+"

FULL_LINK = 'http://ports.ubuntu.com/ubuntu-ports/pool/main/h/heimdal/libwind0-heimdal_7.7.0+dfsg-1ubuntu1_arm64.deb'

DEB_NAME = 'libwind0-heimdal_7.7.0+dfsg-1ubuntu1_arm64.deb'

SRC_URI[md5sum] = "9527f7eca32d10e4f194c82f3ee010ac"
