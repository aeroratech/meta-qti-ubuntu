inherit deb-dl

LICENSE = "BSD-3-Clause"

FULL_LINK = 'http://ports.ubuntu.com/ubuntu-ports/pool/main/libv/libvorbis/libvorbis0a_1.3.6-2ubuntu1_arm64.deb'

DEB_NAME = 'libvorbis0a_1.3.6-2ubuntu1_arm64.deb'

SRC_URI[md5sum] = "a238e44dc233734cc707d08110b927d0"
