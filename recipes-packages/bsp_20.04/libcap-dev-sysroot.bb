inherit deb-dl

LICENSE = "BSD-3-clause | GPL-2.0"

FULL_LINK = 'http://ports.ubuntu.com/ubuntu-ports/pool/main/libc/libcap2/libcap-dev_2.32-1_arm64.deb'

DEB_NAME = 'libcap-dev_2.32-1_arm64.deb'

SRC_URI[md5sum] = "2a3e9324968a2b72c90f6c1a2a4a413b"
