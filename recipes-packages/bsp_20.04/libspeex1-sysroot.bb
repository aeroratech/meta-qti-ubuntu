inherit deb-dl

LICENSE = "BSD-3-Clause"

FULL_LINK = 'http://ports.ubuntu.com/ubuntu-ports/pool/main/s/speex/libspeex1_1.2~rc1.2-1.1ubuntu1_arm64.deb'

DEB_NAME = 'libspeex1_1.2~rc1.2-1.1ubuntu1_arm64.deb'

SRC_URI[md5sum] = "cb4c9a0e80d8b58ed41b26332cd99651"
