inherit deb-dl

LICENSE = "BSD-3-clause"

FULL_LINK = 'http://ports.ubuntu.com/ubuntu-ports/pool/main/p/pam/libpam0g_1.3.1-5ubuntu4_arm64.deb'

DEB_NAME = 'libpam0g_1.3.1-5ubuntu4_arm64.deb'

SRC_URI[md5sum] = "06a030983fe87f9e38ed250d05495a0c"
