inherit deb-dl

LICENSE = "GPL-2.0+"

FULL_LINK = 'http://ports.ubuntu.com/ubuntu-ports/pool/universe/a/a52dec/liba52-0.7.4_0.7.4-20_arm64.deb'

DEB_NAME = 'liba52-0.7.4_0.7.4-20_arm64.deb'

SRC_URI[md5sum] = "81df7b3d55df5472d00ee80940725d5f"
