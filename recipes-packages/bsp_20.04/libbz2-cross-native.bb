inherit native deb-dl

LICENSE = "BSD-variant"

FULL_LINK = 'http://ports.ubuntu.com/ubuntu-ports/pool/main/b/bzip2/libbz2-1.0_1.0.8-2_arm64.deb'

DEB_NAME = 'libbz2-1.0_1.0.8-2_arm64.deb'

SRC_URI[md5sum] = "b264cacc4783b91a49c929abf9a997e6"
