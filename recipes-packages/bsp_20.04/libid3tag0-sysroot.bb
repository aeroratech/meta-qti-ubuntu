inherit deb-dl

LICENSE = "GPL-2.0+"

FULL_LINK = 'http://ports.ubuntu.com/ubuntu-ports/pool/universe/libi/libid3tag/libid3tag0_0.15.1b-14_arm64.deb'

DEB_NAME = 'libid3tag0_0.15.1b-14_arm64.deb'

SRC_URI[md5sum] = "4401df386eafa31cda97c57e6dbf615f"
