inherit deb-dl

LICENSE = "GFDL-1.1+ & BSD-3-Clause & GPL-2+ & LGPL-2.1+ & PD & ISC"

FULL_LINK = 'http://ports.ubuntu.com/ubuntu-ports/pool/main/f/flac/libflac8_1.3.3-1build1_arm64.deb'

DEB_NAME = 'libflac8_1.3.3-1build1_arm64.deb'

SRC_URI[md5sum] = "d083b2c6b1eb5eba9a0475bc25550e8f"
