inherit deb-dl	

LICENSE = "MIT & BSD-2-clause"

FULL_LINK = 'http://ports.ubuntu.com/ubuntu-ports/pool/universe/s/spdlog/libspdlog1_1.5.0-1_arm64.deb'

DEB_NAME = 'libspdlog1_1.5.0-1_arm64.deb'

SRC_URI[md5sum] = "54ba4e06912d57bda3442ac7386d0894"
