inherit deb-dl

LICENSE = " MIT"

FULL_LINK = 'http://ports.ubuntu.com/ubuntu-ports/pool/main/libd/libdrm/libdrm-freedreno1_2.4.101-2_arm64.deb'

DEB_NAME = 'libdrm-freedreno1_2.4.101-2_arm64.deb'

SRC_URI[md5sum] = "d778dd2c5c7f7928845a6bed2b45e9df"
