inherit deb-dl

LICENSE = "MIT & BSD-3-Clause & more"

FULL_LINK = 'http://ports.ubuntu.com/ubuntu-ports/pool/main/k/krb5/libgssapi-krb5-2_1.17-6ubuntu4_arm64.deb'

DEB_NAME = 'libgssapi-krb5-2_1.17-6ubuntu4_arm64.deb'

SRC_URI[md5sum] = "89974c47de698deaaf6c78d0d66a9757"
