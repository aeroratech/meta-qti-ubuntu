inherit deb-dl

LICENSE = "BSD-3-clause"

FULL_LINK = 'http://ports.ubuntu.com/ubuntu-ports/pool/main/s/speex/libspeex-dev_1.2~rc1.2-1.1ubuntu1_arm64.deb'

DEB_NAME = 'libspeex-dev_1.2~rc1.2-1.1ubuntu1_arm64.deb'

SRC_URI[md5sum] = "688f4124c99fa1456a00011b830ac0aa"
