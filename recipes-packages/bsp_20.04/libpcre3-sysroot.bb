inherit deb-dl

LICENSE = "BSD-3-Clause"

FULL_LINK = 'http://ports.ubuntu.com/ubuntu-ports/pool/main/p/pcre3/libpcre3_8.39-12build1_arm64.deb'

DEB_NAME = 'libpcre3_8.39-12build1_arm64.deb'

SRC_URI[md5sum] = "5468d33e7cb52ac5faf8c3e7666ba4f5"
