inherit deb-dl

LICENSE = "MIT & ISC"

FULL_LINK = 'http://ports.ubuntu.com/ubuntu-ports/pool/main/libp/libpciaccess/libpciaccess0_0.16-0ubuntu1_arm64.deb'

DEB_NAME = 'libpciaccess0_0.16-0ubuntu1_arm64.deb'

SRC_URI[md5sum] = "04829f610086417a8f80c664d36254db"
