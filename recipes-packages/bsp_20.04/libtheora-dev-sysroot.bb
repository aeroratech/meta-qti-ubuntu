inherit deb-dl

LICENSE = "BSD-3-clause"

FULL_LINK = 'http://ports.ubuntu.com/ubuntu-ports/pool/main/libt/libtheora/libtheora-dev_1.1.1+dfsg.1-15ubuntu2_arm64.deb'

DEB_NAME = 'libtheora-dev_1.1.1+dfsg.1-15ubuntu2_arm64.deb'

SRC_URI[md5sum] = "2532cf49b9f912b20b87bad228b031b6"
