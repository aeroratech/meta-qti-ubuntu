inherit deb-dl

LICENSE = "MIT"

FULL_LINK = 'http://ports.ubuntu.com/ubuntu-ports/pool/main/m/mtdev/libmtdev-dev_1.1.5-1.1_arm64.deb'

DEB_NAME = 'libmtdev-dev_1.1.5-1.1_arm64.deb'

SRC_URI[md5sum] = "c595b8d042359e3c3cd737c31f2e031a"
