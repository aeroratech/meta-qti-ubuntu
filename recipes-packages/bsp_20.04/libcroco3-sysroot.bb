inherit deb-dl

LICENSE = "LGPL-2.0+"

FULL_LINK = 'http://ports.ubuntu.com/ubuntu-ports/pool/main/libc/libcroco/libcroco3_0.6.13-1_arm64.deb'

DEB_NAME = 'libcroco3_0.6.13-1_arm64.deb'

SRC_URI[md5sum] = "7db73a023f7760ddfc7a35a8be15a43e"
