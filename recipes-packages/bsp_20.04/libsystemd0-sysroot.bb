inherit deb-dl

LICENSE = "LGPL-2.1+ & CCO-1.0 & GPL-2.0-with-Linux-syscall-note-exception & GPL-2.0+ & MIT"

FULL_LINK = 'http://ports.ubuntu.com/ubuntu-ports/pool/main/s/systemd/libsystemd0_245.4-4ubuntu3_arm64.deb'

DEB_NAME = 'libsystemd0_245.4-4ubuntu3_arm64.deb'

SRC_URI[md5sum] = "66ee9f17f0d934a37b2ff930e3bef563"
