inherit deb-dl

LICENSE = "LGPL-2.1 | MPL-1.1 & BSD-2-clause"

FULL_LINK = 'http://ports.ubuntu.com/ubuntu-ports/pool/main/t/taglib/libtagc0_1.11.1+dfsg.1-0.3ubuntu2_arm64.deb'

DEB_NAME = 'libtagc0_1.11.1+dfsg.1-0.3ubuntu2_arm64.deb'

SRC_URI[md5sum] = "c5b13ce0bb7a26d211f494461658c9b4"
