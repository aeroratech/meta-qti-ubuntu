inherit deb-dl

LICENSE = "LGPL-2.1+ & LGPL-2.0+ & BSD-3-Clause & GPL-2.0+"

FULL_LINK = 'http://ports.ubuntu.com/ubuntu-ports/pool/main/n/nettle/libnettle7_3.5.1+really3.5.1-2_arm64.deb'

DEB_NAME = 'libnettle7_3.5.1+really3.5.1-2_arm64.deb'

SRC_URI[md5sum] = "7bfb9cc57bc7c3cd1d4f7ba220d40bfa"
