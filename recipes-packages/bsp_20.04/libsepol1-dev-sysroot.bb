inherit deb-dl

LICENSE = "LGPL-2.1+ & GPL-2.0"

FULL_LINK = 'http://ports.ubuntu.com/ubuntu-ports/pool/main/libs/libsepol/libsepol1-dev_3.0-1_arm64.deb'

DEB_NAME = 'libsepol1-dev_3.0-1_arm64.deb'

SRC_URI[md5sum] = "d81cc3b116cbbc63c6096eb55ac44685"
