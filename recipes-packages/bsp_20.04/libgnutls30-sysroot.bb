inherit deb-dl

LICENSE = "LGPL-2.1+ & GPL-3.0+"

FULL_LINK = 'http://ports.ubuntu.com/ubuntu-ports/pool/main/g/gnutls28/libgnutls30_3.6.13-2ubuntu1_arm64.deb'

DEB_NAME = 'libgnutls30_3.6.13-2ubuntu1_arm64.deb'

SRC_URI[md5sum] = "6978fc5b135070bb531e225da0c352e5"
