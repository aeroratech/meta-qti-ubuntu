inherit deb-dl

LICENSE = "MIT"

FULL_LINK = 'http://ports.ubuntu.com/ubuntu-ports/pool/main/e/expat/libexpat1-dev_2.2.9-1build1_arm64.deb'

DEB_NAME = 'libexpat1-dev_2.2.9-1build1_arm64.deb'

SRC_URI[md5sum] = "efc8240a49b99cdeffed4150d5bf294d"
