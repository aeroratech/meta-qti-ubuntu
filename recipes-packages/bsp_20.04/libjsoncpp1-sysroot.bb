inherit deb-dl

LICENSE = "MIT | PD & GPL-3.0+"

FULL_LINK = 'http://ports.ubuntu.com/ubuntu-ports/pool/main/libj/libjsoncpp/libjsoncpp1_1.7.4-3.1ubuntu2_arm64.deb'

DEB_NAME = 'libjsoncpp1_1.7.4-3.1ubuntu2_arm64.deb'

SRC_URI[md5sum] = "3c3dd0461f04d1fd57927c5949a6992e"
