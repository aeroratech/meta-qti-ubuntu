inherit deb-dl

LICENSE = "X11 & MIT & GPL-2.0+ & Apache-2.0 & BSD-3-Clause"

FULL_LINK = 'http://ports.ubuntu.com/ubuntu-ports/pool/main/libe/libevdev/libevdev2_1.9.0+dfsg-1_arm64.deb'

DEB_NAME = 'libevdev2_1.9.0+dfsg-1_arm64.deb'

SRC_URI[md5sum] = "3405d5ab302ef8ea58ca7b1ed50a4098"
