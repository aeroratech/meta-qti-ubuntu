inherit deb-dl

LICENSE = "MIT-Style & BSD-3-Clause"

FULL_LINK = 'http://ports.ubuntu.com/ubuntu-ports/pool/main/n/ncurses/libtinfo-dev_6.2-0ubuntu2_arm64.deb'

DEB_NAME = 'libtinfo-dev_6.2-0ubuntu2_arm64.deb'

SRC_URI[md5sum] = "d33ac4c91d7b24d7441b2816232ffaad"
