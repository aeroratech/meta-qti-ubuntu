inherit deb-dl

LICENSE = "BSD-4-clause & GPL-3.0+"

FULL_LINK = 'http://ports.ubuntu.com/ubuntu-ports/pool/main/c/cyrus-sasl2/libsasl2-2_2.1.27+dfsg-2_arm64.deb'

DEB_NAME = 'libsasl2-2_2.1.27+dfsg-2_arm64.deb'

SRC_URI[md5sum] = "9b1c5813544e614d2c1fb01bcbd4e5e6"
