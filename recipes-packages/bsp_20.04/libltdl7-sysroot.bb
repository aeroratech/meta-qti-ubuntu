inherit deb-dl

LICENSE = "GPL-2.0+ & GFDL-1.3+"

FULL_LINK = 'http://ports.ubuntu.com/ubuntu-ports/pool/main/libt/libtool/libltdl7_2.4.6-14_arm64.deb'

DEB_NAME = 'libltdl7_2.4.6-14_arm64.deb'

SRC_URI[md5sum] = "13e8e3afac4e54656026df8c879901b8"
