inherit deb-dl

LICENSE = "Various licenses"

#LIC_FILES_CHKSUM = "\
#    file://https://changelogs.ubuntu.com/changelogs/pool/main/t/tcp-wrappers/tcp-wrappers_7.6.q-30/copyright;md5=aebfac90929f6a69f2aa763213476b7d \
#"

FULL_LINK = 'http://ports.ubuntu.com/ubuntu-ports/pool/main/t/tcp-wrappers/libwrap0_7.6.q-30_arm64.deb'

DEB_NAME = 'libwrap0_7.6.q-30_arm64.deb'

SRC_URI[md5sum] = "03743e521b067cbdc32febe24d93422c"
