inherit deb-dl

LICENSE = "libpng"

FULL_LINK = 'http://ports.ubuntu.com/ubuntu-ports/pool/main/libp/libpng1.6/libpng16-16_1.6.37-2_arm64.deb'

DEB_NAME = 'libpng16-16_1.6.37-2_arm64.deb'

SRC_URI[md5sum] = "b3e8d85f27cec8f023a7e291b31d5fab"
