inherit deb-dl

LICENSE = "BSD-3-Clause & GPL-2.0+"

FULL_LINK = 'http://ports.ubuntu.com/ubuntu-ports/pool/main/h/heimdal/libroken18-heimdal_7.7.0+dfsg-1ubuntu1_arm64.deb'

DEB_NAME = 'libroken18-heimdal_7.7.0+dfsg-1ubuntu1_arm64.deb'

SRC_URI[md5sum] = "423022faea620f33f65a69290f961eae"
