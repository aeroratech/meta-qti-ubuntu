inherit deb-dl

LICENSE = "OpenSSL & SSLeay"

FULL_LINK = 'http://ports.ubuntu.com/ubuntu-ports/pool/main/o/openssl/openssl_1.1.1f-1ubuntu2_arm64.deb'

DEB_NAME = 'openssl_1.1.1f-1ubuntu2_arm64.deb'

SRC_URI[md5sum] = "85c91bb06e8d96a8484245e24d47402a"
