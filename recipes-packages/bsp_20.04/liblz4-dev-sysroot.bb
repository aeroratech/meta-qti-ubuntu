inherit deb-dl

LICENSE = "BSD-2-clause & GPL-2.0+"

FULL_LINK = 'http://ports.ubuntu.com/ubuntu-ports/pool/main/l/lz4/liblz4-dev_1.9.2-2_arm64.deb'

DEB_NAME = 'liblz4-dev_1.9.2-2_arm64.deb'

SRC_URI[md5sum] = "852272923e25d005cd60d388d8a9eee8"
