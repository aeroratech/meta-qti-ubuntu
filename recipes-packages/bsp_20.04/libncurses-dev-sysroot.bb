inherit deb-dl

LICENSE = "MIT-Style & BSD-3-Clause"

FULL_LINK = 'http://ports.ubuntu.com/ubuntu-ports/pool/main/n/ncurses/libncurses-dev_6.2-0ubuntu2_arm64.deb'

DEB_NAME = 'libncurses-dev_6.2-0ubuntu2_arm64.deb'

SRC_URI[md5sum] = "66c44f6899891067c4129bf666f513d9"
