inherit deb-dl

LICENSE = "LGPL-2.1+ & GPL-2.0"

FULL_LINK = 'http://ports.ubuntu.com/ubuntu-ports/pool/main/libs/libsepol/libsepol1_3.0-1_arm64.deb'

DEB_NAME = 'libsepol1_3.0-1_arm64.deb'

SRC_URI[md5sum] = "675f872f99c4e534cfd2f33a1c155cfb"
