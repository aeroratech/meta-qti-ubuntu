inherit deb-dl

LICENSE = "MIT"

FULL_LINK = 'http://ports.ubuntu.com/ubuntu-ports/pool/main/p/pixman/libpixman-1-0_0.38.4-0ubuntu1_arm64.deb'

DEB_NAME = 'libpixman-1-0_0.38.4-0ubuntu1_arm64.deb'

SRC_URI[md5sum] = "e1809b7a8649aa876920a5a803ba48a4"
