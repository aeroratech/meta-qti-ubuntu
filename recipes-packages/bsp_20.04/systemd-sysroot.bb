inherit deb-dl

LICENSE = "LGPL-2.1+ & CCO-1.0 & GPL-2-with-Linux-syscall-note-exception & GPL-2.0+"

FULL_LINK = 'http://ports.ubuntu.com/ubuntu-ports/pool/main/s/systemd/systemd_245.4-4ubuntu3_arm64.deb'

DEB_NAME = 'systemd_245.4-4ubuntu3_arm64.deb'

SRC_URI[md5sum] = "c7751be82e38c95b3ef69ca3444f56a0"
