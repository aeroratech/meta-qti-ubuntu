inherit deb-dl

LICENSE = "MIT-style & MIT"

FULL_LINK = 'http://ports.ubuntu.com/ubuntu-ports/pool/main/libx/libxfixes/libxfixes3_5.0.3-1_arm64.deb'
DEB_NAME = 'libxfixes3_5.0.3-1_arm64.deb'

SRC_URI[md5sum] = "49a6d2acfaaa98cfd970258fecdbddb1"
