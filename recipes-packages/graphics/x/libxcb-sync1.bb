inherit deb-dl

LICENSE = "MIT-style"

FULL_LINK = 'http://ports.ubuntu.com/ubuntu-ports/pool/main/libx/libxcb/libxcb-sync1_1.13-1_arm64.deb'
DEB_NAME = 'libxcb-sync1_1.13-1_arm64.deb'

SRC_URI[md5sum] = "b3f4bbce928cd98114dd90d35f1c1b5e"
