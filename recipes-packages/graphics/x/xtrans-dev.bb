inherit deb-dl

LICENSE = "MIT-style & MIT"

FULL_LINK = 'http://ports.ubuntu.com/ubuntu-ports/pool/main/x/xtrans/xtrans-dev_1.3.5-1_all.deb'
DEB_NAME = 'xtrans-dev_1.3.5-1_all.deb'

SRC_URI[md5sum] = "307b4043a431a1904e6f4759150a15e1"
