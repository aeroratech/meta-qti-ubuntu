inherit deb-dl

LICENSE = "MIT-style"

FULL_LINK = 'http://ports.ubuntu.com/ubuntu-ports/pool/main/libx/libxtst/libxtst-dev_1.2.3-1_arm64.deb'
DEB_NAME = 'libxtst-dev_1.2.3-1_arm64.deb'

SRC_URI[md5sum] = "31329682de2ad745011b441287e1639b"
