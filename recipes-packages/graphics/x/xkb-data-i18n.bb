inherit deb-dl

LICENSE = "MIT-style"

FULL_LINK = 'http://ports.ubuntu.com/ubuntu-ports/pool/universe/x/xkeyboard-config/xkb-data-i18n_2.23.1-1ubuntu1_all.deb'
DEB_NAME = 'xkb-data-i18n_2.23.1-1ubuntu1_all.deb'

SRC_URI[md5sum] = "61cc1cc461be0362041ad6ece411e7be"
