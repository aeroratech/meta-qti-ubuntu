inherit deb-dl

LICENSE = "MIT-style"

FULL_LINK = 'http://ports.ubuntu.com/ubuntu-ports/pool/main/x/xkeyboard-config/xkb-data_2.23.1-1ubuntu1_all.deb'
DEB_NAME = 'xkb-data_2.23.1-1ubuntu1_all.deb'

SRC_URI[md5sum] = "fda8a3ee1d3641917a6170266ba47a5c"
