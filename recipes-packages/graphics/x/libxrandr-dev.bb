inherit deb-dl

LICENSE = "MIT-style"

FULL_LINK = 'http://ports.ubuntu.com/ubuntu-ports/pool/main/libx/libxrandr/libxrandr-dev_1.5.1-1_arm64.deb'
DEB_NAME = 'libxrandr-dev_1.5.1-1_arm64.deb'

SRC_URI[md5sum] = "6a468488d05e8bb5e31f1003eb2e1a53"
