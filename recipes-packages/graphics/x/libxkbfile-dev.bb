inherit deb-dl

LICENSE = "MIT-style"

FULL_LINK = 'http://ports.ubuntu.com/ubuntu-ports/pool/main/libx/libxkbfile/libxkbfile-dev_1.0.9-2_arm64.deb'
DEB_NAME = 'libxkbfile-dev_1.0.9-2_arm64.deb'

SRC_URI[md5sum] = "663e950286ed5d03ec6f5fc48bb02b71"
