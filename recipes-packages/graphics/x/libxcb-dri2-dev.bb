inherit deb-dl

LICENSE = "MIT-style"

FULL_LINK = 'http://ports.ubuntu.com/ubuntu-ports/pool/main/libx/libxcb/libxcb-dri2-0-dev_1.13-2~ubuntu18.04_arm64.deb'
DEB_NAME = 'libxcb-dri2-0-dev_1.13-2~ubuntu18.04_arm64.deb'

SRC_URI[md5sum] = "eeea73b1f796472299bcabbc8cdaf4bb"
