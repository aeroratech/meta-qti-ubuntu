inherit deb-dl

LICENSE = "MIT-style"

FULL_LINK = 'http://ports.ubuntu.com/ubuntu-ports/pool/main/libx/libxcb/libxcb-xfixes0-dev_1.13-1_arm64.deb'
DEB_NAME = 'libxcb-xfixes0-dev_1.13-1_arm64.deb'

SRC_URI[md5sum] = "f788cf6264feca3cb5c3ed4cd8a5e375"
