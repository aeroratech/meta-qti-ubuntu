inherit deb-dl

LICENSE = "MIT-style"

FULL_LINK = 'http://ports.ubuntu.com/ubuntu-ports/pool/main/libx/libxdamage/libxdamage-dev_1.1.4-3_arm64.deb'
DEB_NAME = 'libxdamage-dev_1.1.4-3_arm64.deb'

SRC_URI[md5sum] = "7e2462adbab9f25f50e322a79d190299"
