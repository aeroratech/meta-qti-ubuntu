inherit deb-dl

LICENSE = "MIT-style"

FULL_LINK = 'http://ports.ubuntu.com/ubuntu-ports/pool/main/libx/libxcb/libxcb-glx0-dev_1.13-1_arm64.deb'
DEB_NAME = 'libxcb-glx0-dev_1.13-1_arm64.deb'

PACKAGES = "libxcb-glx0-dev"

SRC_URI[md5sum] = "523fb14b39676111407a0e46b6673dd2"
