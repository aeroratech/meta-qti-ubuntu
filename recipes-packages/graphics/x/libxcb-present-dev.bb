inherit deb-dl

LICENSE = "MIT-style"

FULL_LINK = 'http://ports.ubuntu.com/ubuntu-ports/pool/main/libx/libxcb/libxcb-present-dev_1.13-1_arm64.deb'
DEB_NAME = 'libxcb-present-dev_1.13-1_arm64.deb'

SRC_URI[md5sum] = "5be516e24fe3e973d0d1bf5ecb539cc8"
