inherit deb-dl

LICENSE = "MIT-style"

FULL_LINK = 'http://ports.ubuntu.com/ubuntu-ports/pool/main/libx/libxcb/libxcb-randr0-dev_1.13-1_arm64.deb'
DEB_NAME = 'libxcb-randr0-dev_1.13-1_arm64.deb'

SRC_URI[md5sum] = "a3d58dc23503b3bba7183d58e06e4193"
