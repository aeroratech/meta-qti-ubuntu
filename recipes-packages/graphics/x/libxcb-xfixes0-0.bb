inherit deb-dl

LICENSE = "MIT-style"

FULL_LINK = 'http://ports.ubuntu.com/ubuntu-ports/pool/main/libx/libxcb/libxcb-xfixes0_1.13-1_arm64.deb'
DEB_NAME = 'libxcb-xfixes0_1.13-1_arm64.deb'

SRC_URI[md5sum] = "97ed836a46a919ac52c9ede5a8ecf341"
