inherit deb-dl

LICENSE = "MIT-style & MIT & BSD-2-Clause & BSD-4-Clause"

FULL_LINK = 'http://ports.ubuntu.com/ubuntu-ports/pool/main/libx/libxfont/libxfont-dev_2.0.3-1_arm64.deb'
DEB_NAME = 'libxfont-dev_2.0.3-1_arm64.deb'

SRC_URI[md5sum] = "2a915932751565c5c338567076f55aac"
