inherit deb-dl

LICENSE = "MIT-style"

FULL_LINK = 'http://ports.ubuntu.com/ubuntu-ports/pool/main/libi/libice/libice6_1.0.9-2_arm64.deb'
DEB_NAME = 'libice6_1.0.9-2_arm64.deb'

SRC_URI[md5sum] = "f6a545737113047023eb8bfa331a34b1"
