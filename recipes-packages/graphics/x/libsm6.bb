inherit deb-dl

LICENSE = "MIT-style"

FULL_LINK = 'http://ports.ubuntu.com/ubuntu-ports/pool/main/libs/libsm/libsm6_1.2.2-1_arm64.deb'
DEB_NAME = 'libsm6_1.2.2-1_arm64.deb'

SRC_URI[md5sum] = "2189eb69dae1abe86292c1a11a16c5cd"
