inherit deb-dl

LICENSE = "MIT-style"

FULL_LINK = 'http://ports.ubuntu.com/ubuntu-ports/pool/main/libx/libxcb/libxcb-shape0_1.13-1_arm64.deb'
DEB_NAME = 'libxcb-shape0_1.13-1_arm64.deb'

SRC_URI[md5sum] = "a12e9ab1d7377fa986d1d66d3a577a16"
