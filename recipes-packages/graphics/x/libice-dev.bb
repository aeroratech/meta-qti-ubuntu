inherit deb-dl

LICENSE = "MIT-style"

FULL_LINK = 'http://ports.ubuntu.com/ubuntu-ports/pool/main/libi/libice/libice-dev_1.0.9-2_arm64.deb'
DEB_NAME = 'libice-dev_1.0.9-2_arm64.deb'

SRC_URI[md5sum] = "95f3d980ae97f37ae19743e54e57c5fb"
