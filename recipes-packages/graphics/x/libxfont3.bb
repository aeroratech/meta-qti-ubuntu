inherit deb-dl

LICENSE = "MIT-style & MIT & BSD-2-Clause & BSD-4-Clause"

FULL_LINK = 'http://ports.ubuntu.com/ubuntu-ports/pool/main/libx/libxfont/libxfont2_2.0.3-1_arm64.deb'
DEB_NAME = 'libxfont2_2.0.3-1_arm64.deb'

SRC_URI[md5sum] = "c1899d410191ee3070a283886e178acb"
