inherit deb-dl

LICENSE = "MIT-style"

FULL_LINK = 'http://ports.ubuntu.com/ubuntu-ports/pool/main/libx/libxdamage/libxdamage1_1.1.4-3_arm64.deb'
DEB_NAME = 'libxdamage1_1.1.4-3_arm64.deb'

SRC_URI[md5sum] = "d4f2626fb49d37ce82bb103831ec063d"
