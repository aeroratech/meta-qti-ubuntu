inherit deb-dl

LICENSE = "MIT-style"

FULL_LINK = 'http://ports.ubuntu.com/ubuntu-ports/pool/main/libx/libxshmfence/libxshmfence1_1.3-1_arm64.deb'
DEB_NAME = 'libxshmfence1_1.3-1_arm64.deb'

SRC_URI[md5sum] = "4bdad15e463a4c3b7732f960c3ad0f73"
