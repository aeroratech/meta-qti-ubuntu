inherit deb-dl

LICENSE = "MIT-style"

FULL_LINK = 'http://ports.ubuntu.com/ubuntu-ports/pool/main/libs/libsm/libsm-dev_1.2.2-1_arm64.deb'
DEB_NAME = 'libsm-dev_1.2.2-1_arm64.deb'

SRC_URI[md5sum] = "dbf75d312f6c6d6cb88312cd040f3676"
