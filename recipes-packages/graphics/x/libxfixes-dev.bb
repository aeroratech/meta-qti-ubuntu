inherit deb-dl

LICENSE = "MIT-style & MIT"

FULL_LINK = 'http://ports.ubuntu.com/ubuntu-ports/pool/main/libx/libxfixes/libxfixes-dev_5.0.3-1_arm64.deb'
DEB_NAME = 'libxfixes-dev_5.0.3-1_arm64.deb'

SRC_URI[md5sum] = "8cf11ccc8e3fcb75655a01f51c42562b"
