inherit deb-dl

LICENSE = "MIT-style & MIT"

FULL_LINK = 'http://ports.ubuntu.com/ubuntu-ports/pool/main/libx/libxi/libxi6_1.7.9-1_arm64.deb'
DEB_NAME = 'libxi6_1.7.9-1_arm64.deb'

SRC_URI[md5sum] = "c597c5e6cfcd6c15fb45d80118681aad"
