inherit deb-dl

LICENSE = "MIT-style"

FULL_LINK = 'http://ports.ubuntu.com/ubuntu-ports/pool/main/libx/libxxf86vm/libxxf86vm-dev_1.1.4-1_arm64.deb'
DEB_NAME = 'libxxf86vm-dev_1.1.4-1_arm64.deb'

SRC_URI[md5sum] = "dea2b963a0ebdb2f889a2b80bbadd137"
