inherit deb-dl

LICENSE = "MIT-style"

FULL_LINK = 'http://ports.ubuntu.com/ubuntu-ports/pool/main/libx/libxcb/libxcb-glx0_1.13-1_arm64.deb'
DEB_NAME = 'libxcb-glx0_1.13-1_arm64.deb'

PACKAGES = "libxcb-glx0"

SRC_URI[md5sum] = "7f34e616bf4db2f951ee278eebd8930d"
