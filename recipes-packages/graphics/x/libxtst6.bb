inherit deb-dl

LICENSE = "MIT-style"

FULL_LINK = 'http://ports.ubuntu.com/ubuntu-ports/pool/main/libx/libxtst/libxtst6_1.2.3-1_arm64.deb'
DEB_NAME = 'libxtst6_1.2.3-1_arm64.deb'

SRC_URI[md5sum] = "a4ae34aa761976d1c275ff11b34bf607"
