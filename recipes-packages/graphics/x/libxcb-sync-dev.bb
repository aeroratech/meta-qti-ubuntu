inherit deb-dl

LICENSE = "MIT-style"

FULL_LINK = 'http://ports.ubuntu.com/ubuntu-ports/pool/main/libx/libxcb/libxcb-sync-dev_1.13-1_arm64.deb'
DEB_NAME = 'libxcb-sync-dev_1.13-1_arm64.deb'

SRC_URI[md5sum] = "b28da8138ee25eb8e2968bd49930fafc"
