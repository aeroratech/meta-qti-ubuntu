inherit deb-dl

LICENSE = "MIT-style"

FULL_LINK = 'http://ports.ubuntu.com/ubuntu-ports/pool/main/libx/libxcb/libxcb-shape0-dev_1.13-1_arm64.deb'
DEB_NAME = 'libxcb-shape0-dev_1.13-1_arm64.deb'

SRC_URI[md5sum] = "2682c611b37ab04064d798407863b37b"
