inherit deb-dl

LICENSE = "MIT-style"

FULL_LINK = 'http://ports.ubuntu.com/ubuntu-ports/pool/main/x/xfonts-utils/xfonts-utils_7.7+6_arm64.deb'
DEB_NAME = 'xfonts-utils_7.7+6_arm64.deb'

SRC_URI[md5sum] = "0ebe78537e98f6d284a567a8ff4d1b5d"
