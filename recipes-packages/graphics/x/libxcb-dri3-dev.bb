inherit deb-dl

LICENSE = "MIT-style"

FULL_LINK = 'http://ports.ubuntu.com/ubuntu-ports/pool/main/libx/libxcb/libxcb-dri3-dev_1.13-1_arm64.deb'
DEB_NAME = 'libxcb-dri3-dev_1.13-1_arm64.deb'

SRC_URI[md5sum] = "59cd9da0aceb1f778b18e0c8e0cc5e73"
