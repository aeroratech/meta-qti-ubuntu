inherit deb-dl

LICENSE = "MIT-style"

FULL_LINK = 'http://ports.ubuntu.com/ubuntu-ports/pool/main/libx/libxcb/libxcb-randr0_1.13-1_arm64.deb'
DEB_NAME = 'libxcb-randr0_1.13-1_arm64.deb'

SRC_URI[md5sum] = "b1c79476e6fca65046d5efe024ed7664"
