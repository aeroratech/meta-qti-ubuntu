inherit deb-dl

LICENSE = "MIT-style"

FULL_LINK = 'http://ports.ubuntu.com/ubuntu-ports/pool/main/libx/libxcb/libxcb-dri3-0_1.13-1_arm64.deb'
DEB_NAME = 'libxcb-dri3-0_1.13-1_arm64.deb'

SRC_URI[md5sum] = "e631f6e28c667b9c3ee54e5b3bb7ac1b"
