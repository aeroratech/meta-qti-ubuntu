inherit deb-dl

LICENSE = "MIT-style"

FULL_LINK = 'http://ports.ubuntu.com/ubuntu-ports/pool/main/libx/libxxf86vm/libxxf86vm1_1.1.4-1_arm64.deb'
DEB_NAME = 'libxxf86vm1_1.1.4-1_arm64.deb'

SRC_URI[md5sum] = "7157b51b0cb12358fcd7dc8ff81e193a"
