inherit deb-dl

LICENSE = "MIT-style"

FULL_LINK = 'http://ports.ubuntu.com/ubuntu-ports/pool/main/libx/libxrandr/libxrandr2_1.5.1-1_arm64.deb'
DEB_NAME = 'libxrandr2_1.5.1-1_arm64.deb'

SRC_URI[md5sum] = "46a12fd1d89f005d68a9eff263d9ac28"
