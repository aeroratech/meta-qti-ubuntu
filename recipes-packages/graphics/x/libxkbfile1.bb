inherit deb-dl

LICENSE = "MIT-style"

FULL_LINK = 'http://ports.ubuntu.com/ubuntu-ports/pool/main/libx/libxkbfile/libxkbfile1_1.0.9-2_arm64.deb'
DEB_NAME = 'libxkbfile1_1.0.9-2_arm64.deb'

SRC_URI[md5sum] = "e38d7163568011b84a1d05f0c046675f"
