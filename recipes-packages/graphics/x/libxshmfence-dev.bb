inherit deb-dl

LICENSE = "MIT-style"

FULL_LINK = 'http://ports.ubuntu.com/ubuntu-ports/pool/main/libx/libxshmfence/libxshmfence-dev_1.3-1_arm64.deb'
DEB_NAME = 'libxshmfence-dev_1.3-1_arm64.deb'

SRC_URI[md5sum] = "be6cf6d204b700f69197027f6999a550"
