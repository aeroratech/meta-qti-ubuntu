inherit deb-dl

LICENSE = "MIT-style & MIT"

FULL_LINK = 'http://ports.ubuntu.com/ubuntu-ports/pool/main/libx/libxi/libxi-dev_1.7.9-1_arm64.deb'
DEB_NAME = 'libxi-dev_1.7.9-1_arm64.deb'

SRC_URI[md5sum] = "2dd1b863d410bf9646b7b992d9171841"
