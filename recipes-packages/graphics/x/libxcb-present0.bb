inherit deb-dl

LICENSE = "MIT-style"

FULL_LINK = 'http://ports.ubuntu.com/ubuntu-ports/pool/main/libx/libxcb/libxcb-present0_1.13-1_arm64.deb'
DEB_NAME = 'libxcb-present0_1.13-1_arm64.deb'

SRC_URI[md5sum] = "4b88db3e308b65b20c42ee71708bec9c"
