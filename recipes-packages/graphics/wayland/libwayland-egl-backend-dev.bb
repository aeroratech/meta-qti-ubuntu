inherit deb-dl

LICENSE = "X11"

FULL_LINK = 'http://ports.ubuntu.com/pool/main/w/wayland/libwayland-egl-backend-dev_1.16.0-1ubuntu1.1~18.04.3_arm64.deb'
DEB_NAME = 'libwayland-egl-backend-dev_1.16.0-1ubuntu1.1~18.04.3_arm64.deb'

SRC_URI[md5sum] = "c2bc67516a87394a4fb5a5956af70adc"
