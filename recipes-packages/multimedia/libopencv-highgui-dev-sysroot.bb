
LICENSE = "BSD-3-clause"

FULL_LINK = 'http://ports.ubuntu.com/ubuntu-ports/pool/universe/o/opencv/libopencv-highgui-dev_3.2.0+dfsg-4build2_arm64.deb'
DEB_NAME = 'libopencv-highgui-dev_3.2.0+dfsg-4build2_arm64.deb'

SRC_URI[md5sum] = "97ca9f62d0bc87ace6c9a470ce870d14"
