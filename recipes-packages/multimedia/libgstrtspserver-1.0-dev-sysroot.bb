inherit native deb-dl

LICENSE = "LGPLv2+"

FULL_LINK = 'http://ports.ubuntu.com/ubuntu-ports/pool/universe/g/gst-rtsp-server1.0/libgstrtspserver-1.0-dev_1.14.0-1_arm64.deb'
DEB_NAME = 'libgstrtspserver-1.0-dev_1.14.0-1_arm64.deb'

SRC_URI[md5sum] = "89d0b95f2e50c61eefcbde45fc464489"
