inherit native deb-dl

LICENSE = "LGPLv2.1+ & LGPLv2+"

FULL_LINK = 'http://ports.ubuntu.com/ubuntu-ports/pool/main/g/gst-plugins-base1.0/gstreamer1.0-plugins-base_1.14.5-0ubuntu1~18.04.2_arm64.deb'
DEB_NAME = 'gstreamer1.0-plugins-base_1.14.5-0ubuntu1~18.04.2_arm64.deb'

SRC_URI[md5sum] = "e65b0e3f79951f1d4a2101ae8f169ff6"
