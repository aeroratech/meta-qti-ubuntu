inherit native deb-dl

LICENSE = "LGPLv2.1+ & LGPLv2+"

FULL_LINK = 'http://ports.ubuntu.com/ubuntu-ports/pool/main/g/gst-plugins-good1.0/libgstreamer-plugins-good1.0-0_1.14.0-1ubuntu1_arm64.deb'
DEB_NAME = 'libgstreamer-plugins-good1.0-0_1.14.0-1ubuntu1_arm64.deb'

SRC_URI[md5sum] = "c7a8bfb037368fb26e9eb871df76f296"
