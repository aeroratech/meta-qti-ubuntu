inherit native deb-dl

LICENSE = "GPLv2+ & LGPLv2+"

FULL_LINK = 'http://ports.ubuntu.com/ubuntu-ports/pool/main/g/gst-plugins-base1.0/libgstreamer-gl1.0-0_1.14.5-0ubuntu1~18.04.2_arm64.deb'
DEB_NAME = 'libgstreamer-gl1.0-0_1.14.5-0ubuntu1~18.04.2_arm64.deb'

SRC_URI[md5sum] = "bc17dc97c6f78bf50f637f3aef751da2"
