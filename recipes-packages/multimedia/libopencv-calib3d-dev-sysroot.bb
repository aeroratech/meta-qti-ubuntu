
LICENSE = "BSD-3-Clause"

FULL_LINK = 'http://ports.ubuntu.com/ubuntu-ports/pool/universe/o/opencv/libopencv-calib3d-dev_3.2.0+dfsg-4build2_arm64.deb'
DEB_NAME = 'libopencv-calib3d-dev_3.2.0+dfsg-4build2_arm64.deb'

SRC_URI[md5sum] = "12879e6b7136221e844be9c0e54c9cba"
