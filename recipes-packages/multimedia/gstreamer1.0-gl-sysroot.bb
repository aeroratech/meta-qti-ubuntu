inherit native deb-dl

LICENSE = "GPLv2+ & LGPLv2+"

FULL_LINK = 'http://ports.ubuntu.com/ubuntu-ports/pool/main/g/gst-plugins-base1.0/gstreamer1.0-gl_1.14.5-0ubuntu1~18.04.1_arm64.deb'
DEB_NAME = 'gstreamer1.0-gl_1.14.5-0ubuntu1~18.04.1_arm64.deb'

SRC_URI[md5sum] = "307dca40a950ec57cb5c35c711a8a510"
