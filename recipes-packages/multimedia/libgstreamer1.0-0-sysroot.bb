inherit native deb-dl

LICENSE = "LGPLv2.1+ & LGPLv2+"

FULL_LINK = 'http://ports.ubuntu.com/ubuntu-ports/pool/main/g/gstreamer1.0/libgstreamer1.0-0_1.14.5-0ubuntu1~18.04.1_arm64.deb'
DEB_NAME = 'libgstreamer1.0-0_1.14.5-0ubuntu1~18.04.1_arm64.deb'

SRC_URI[md5sum] = "15c3f8c09000027d0b718dcba7136074"
