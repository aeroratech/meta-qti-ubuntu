
LICENSE = "BSD-3-Clause"

FULL_LINK = 'http://ports.ubuntu.com/ubuntu-ports/pool/universe/o/opencv/libopencv-contrib-dev_3.2.0+dfsg-4build2_arm64.deb'
DEB_NAME = 'libopencv-contrib-dev_3.2.0+dfsg-4build2_arm64.deb'

SRC_URI[md5sum] = "0995296ef857cceef542f17912c679d0"
