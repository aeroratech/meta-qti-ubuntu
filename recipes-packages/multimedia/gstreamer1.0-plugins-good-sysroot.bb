inherit native deb-dl

LICENSE = "LGPLv2.1+ & LGPLv2+"

FULL_LINK = 'http://ports.ubuntu.com/ubuntu-ports/pool/main/g/gst-plugins-good1.0/gstreamer1.0-plugins-good_1.14.0-1ubuntu1_arm64.deb'
DEB_NAME = 'gstreamer1.0-plugins-good_1.14.0-1ubuntu1_arm64.deb'

SRC_URI[md5sum] = "1180e365d977cb273379e1e00e2c0769"
