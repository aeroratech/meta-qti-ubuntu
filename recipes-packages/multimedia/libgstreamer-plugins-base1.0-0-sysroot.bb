inherit native deb-dl

LICENSE = "LGPLv2.1+ & LGPLv2+"

FULL_LINK = 'http://ports.ubuntu.com/ubuntu-ports/pool/main/g/gst-plugins-base1.0/libgstreamer-plugins-base1.0-0_1.14.0-2ubuntu1_arm64.deb'
DEB_NAME = 'libgstreamer-plugins-base1.0-0_1.14.0-2ubuntu1_arm64.deb'

SRC_URI[md5sum] = "fba08d496cf9eca9b95cb152ca2a8790" 
