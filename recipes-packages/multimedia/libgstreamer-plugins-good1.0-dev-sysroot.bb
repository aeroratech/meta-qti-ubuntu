inherit native deb-dl

LICENSE = "LGPLv2.1+ & LGPLv2+"

FULL_LINK = 'http://ports.ubuntu.com/ubuntu-ports/pool/main/g/gst-plugins-good1.0/libgstreamer-plugins-good1.0-dev_1.14.5-0ubuntu1~18.04.2_arm64.deb'
DEB_NAME = 'libgstreamer-plugins-good1.0-dev_1.14.5-0ubuntu1~18.04.2_arm64.deb'

SRC_URI[md5sum] = "36a727c1bea70d7276338b060dfe2c03"
