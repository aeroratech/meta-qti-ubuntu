inherit native deb-dl

LICENSE = "LGPLv2.1+ & LGPLv2+"

FULL_LINK = 'http://ports.ubuntu.com/ubuntu-ports/pool/main/g/gstreamer1.0/libgstreamer1.0-dev_1.14.5-0ubuntu1~18.04.1_arm64.deb'
DEB_NAME = 'libgstreamer1.0-dev_1.14.5-0ubuntu1~18.04.1_arm64.deb'

SRC_URI[md5sum] = "45f3ab0b5f1ee692032f04f760570e89"
