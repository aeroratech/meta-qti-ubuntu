
LICENSE = "BSD-3-Clause"

FULL_LINK = 'http://ports.ubuntu.com/ubuntu-ports/pool/universe/o/opencv/libopencv-features2d-dev_3.2.0+dfsg-4build2_arm64.deb'
DEB_NAME = 'libopencv-features2d-dev_3.2.0+dfsg-4build2_arm64.deb'

SRC_URI[md5sum] = "f53d4fb772f2e81109b8b5edcd6c08b9"
