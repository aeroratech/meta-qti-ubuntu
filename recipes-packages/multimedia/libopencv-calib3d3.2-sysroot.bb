
LICENSE = "BSD-3-Clause"

FULL_LINK = 'http://ports.ubuntu.com/ubuntu-ports/pool/universe/o/opencv/libopencv-calib3d3.2_3.2.0+dfsg-4build2_arm64.deb'
DEB_NAME = 'libopencv-calib3d3.2_3.2.0+dfsg-4build2_arm64.deb'

SRC_URI[md5sum] = "4515346c6ad850fec6d70aace266d8b5"
