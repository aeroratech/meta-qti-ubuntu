
LICENSE = "BSD-3-clause"

FULL_LINK = 'http://ports.ubuntu.com/ubuntu-ports/pool/universe/o/opencv/libopencv-shape-dev_3.2.0+dfsg-4build2_arm64.deb'
DEB_NAME = 'libopencv-shape-dev_3.2.0+dfsg-4build2_arm64.deb'

SRC_URI[md5sum] = "37871b2b2329c0130f84032b4f0da430"
