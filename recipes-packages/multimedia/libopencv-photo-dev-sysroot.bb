
LICENSE = "BSD-3-clause"

FULL_LINK = 'http://ports.ubuntu.com/ubuntu-ports/pool/universe/o/opencv/libopencv-photo-dev_3.2.0+dfsg-4build2_arm64.deb'
DEB_NAME = 'libopencv-photo-dev_3.2.0+dfsg-4build2_arm64.deb'

SRC_URI[md5sum] = "112d08afeaeb806269a06c377a635bc0"
