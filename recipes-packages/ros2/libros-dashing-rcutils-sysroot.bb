inherit native deb-dl

LICENSE = "Apache-2.0"
SRC_URI[md5sum] = "b269702e7b43a476d3968dd785b2e730"

FULL_LINK = 'http://packages.ros.org/ros2/ubuntu/pool/main/r/ros-dashing-rcutils/ros-dashing-rcutils_0.7.5-1bionic.20200711.061850_arm64.deb'
DEB_NAME = 'ros-dashing-rcutils_0.7.5-1bionic.20200711.061850_arm64.deb'
