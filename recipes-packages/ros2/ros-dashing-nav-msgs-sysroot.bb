LICENSE = "Apache-2.0"

FULL_LINK = 'http://packages.ros.org/ros2/ubuntu/pool/main/r/ros-dashing-nav-msgs/ros-dashing-nav-msgs_0.7.0-1bionic.20200711.100005_arm64.deb'
DEB_NAME = 'ros-dashing-nav-msgs_0.7.0-1bionic.20200711.100005_arm64.deb'

SRC_URI[md5sum] = "675169fcd2491726e2df529fe3538036"
