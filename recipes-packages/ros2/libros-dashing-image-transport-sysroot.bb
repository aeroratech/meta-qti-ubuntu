LICENSE = "BSD"
SRC_URI[md5sum] = "147d14d18918794de991cdd47af897bc"

FULL_LINK = 'http://packages.ros.org/ros2/ubuntu/pool/main/r/ros-dashing-image-transport/ros-dashing-image-transport_2.1.1-1bionic.20201125.101441_arm64.deb'
DEB_NAME = 'ros-dashing-image-transport_2.1.1-1bionic.20201125.101441_arm64.deb'
