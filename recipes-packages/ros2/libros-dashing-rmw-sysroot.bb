inherit native deb-dl

LICENSE = "Apache-2.0"
SRC_URI[md5sum] = "eb8bfd7c9a27d7488e6a2c1fef1d10b8"

FULL_LINK = 'http://packages.ros.org/ros2/ubuntu/pool/main/r/ros-dashing-rmw/ros-dashing-rmw_0.7.2-1bionic.20200711.062609_arm64.deb'
DEB_NAME = 'ros-dashing-rmw_0.7.2-1bionic.20200711.062609_arm64.deb'
