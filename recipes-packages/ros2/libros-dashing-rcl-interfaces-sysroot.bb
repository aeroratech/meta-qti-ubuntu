LICENSE = "Apache-2.0"

SRC_URI[md5sum] = "51601f8041e102669089093375d62b0f"

FULL_LINK = 'http://packages.ros.org/ros2/ubuntu/pool/main/r/ros-dashing-rcl-interfaces/ros-dashing-rcl-interfaces_0.7.4-1bionic.20201125.065353_arm64.deb'
DEB_NAME = 'ros-dashing-rcl-interfaces_0.7.4-1bionic.20201125.065353_arm64.deb'
