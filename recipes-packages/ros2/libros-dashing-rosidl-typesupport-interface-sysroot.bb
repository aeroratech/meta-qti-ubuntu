inherit native deb-dl

LICENSE = "Apache-2.0"
SRC_URI[md5sum] = "ebbab259420734d51e2d0789ee61c973"

FULL_LINK = 'http://packages.ros.org/ros2/ubuntu/pool/main/r/ros-dashing-rosidl-typesupport-interface/ros-dashing-rosidl-typesupport-interface_0.7.9-1bionic.20200711.055209_arm64.deb'
DEB_NAME = 'ros-dashing-rosidl-typesupport-interface_0.7.9-1bionic.20200711.055209_arm64.deb'
