
LICENSE = "Apache-2.0"

FULL_LINK = 'http://packages.ros.org/ros2/ubuntu/pool/main/r/ros-dashing-ament-cmake-core/ros-dashing-ament-cmake-core_0.7.4-1bionic.20191205.181836_arm64.deb'
DEB_NAME = 'ros-dashing-ament-cmake-core_0.7.4-1bionic.20191205.181836_arm64.deb'

SRC_URI[md5sum] = "59bb91bc01e2cf0dcc6e0a6fc96335b0"
