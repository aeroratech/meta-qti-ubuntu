inherit native deb-dl

LICENSE = "Apache-2.0"
SRC_URI[md5sum] = "ea7fcf3e6a454286df06b1891c3960b4"

FULL_LINK = 'http://packages.ros.org/ros2/ubuntu/pool/main/r/ros-dashing-rosidl-typesupport-c/ros-dashing-rosidl-typesupport-c_0.7.1-1bionic.20200711.065253_arm64.deb'
DEB_NAME = 'ros-dashing-rosidl-typesupport-c_0.7.1-1bionic.20200711.065253_arm64.deb'
