inherit native deb-dl

LICENSE = "Apache-2.0"

SRC_URI[md5sum] = "68b8ac07e5530d1530cc44d429a08e46"

FULL_LINK = 'http://packages.ros.org/ros2/ubuntu/pool/main/r/ros-dashing-rcl-logging-noop/ros-dashing-rcl-logging-noop_0.2.1-1bionic.20200318.033607_arm64.deb'
DEB_NAME = 'ros-dashing-rcl-logging-noop_0.2.1-1bionic.20200318.033607_arm64.deb'
