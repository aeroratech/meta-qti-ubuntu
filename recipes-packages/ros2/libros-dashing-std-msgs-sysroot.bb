inherit native deb-dl

LICENSE = "Apache-2.0"
SRC_URI[md5sum] = "0b1565e4f5ebf05cd9d53e4281e7fc9a"

FULL_LINK = 'http://packages.ros.org/ros2/ubuntu/pool/main/r/ros-dashing-std-msgs/ros-dashing-std-msgs_0.7.0-1bionic.20200318.045823_arm64.deb'
DEB_NAME = 'ros-dashing-std-msgs_0.7.0-1bionic.20200318.045823_arm64.deb'
