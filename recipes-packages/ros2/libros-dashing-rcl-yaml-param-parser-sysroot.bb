LICENSE = "Apache-2.0"
SRC_URI[md5sum] = "b123daad20e965790cdd839d1503b91e"

FULL_LINK = 'http://packages.ros.org/ros2/ubuntu/pool/main/r/ros-dashing-rcl-yaml-param-parser/ros-dashing-rcl-yaml-param-parser_0.7.9-1bionic.20201125.081209_arm64.deb'
DEB_NAME = 'ros-dashing-rcl-yaml-param-parser_0.7.9-1bionic.20201125.081209_arm64.deb'
