inherit native deb-dl

LICENSE = "Apache-2.0"
SRC_URI[md5sum] = "b3c43665f226f0288418499688c6a145"

FULL_LINK = 'http://packages.ros.org/ros2/ubuntu/pool/main/r/ros-dashing-rosidl-generator-c/ros-dashing-rosidl-generator-c_0.7.9-1bionic.20200711.055326_arm64.deb'
DEB_NAME = 'ros-dashing-rosidl-generator-c_0.7.9-1bionic.20200711.055326_arm64.deb'
