LICENSE = "BSD"
SRC_URI[md5sum] = "98c222318dc8655625914933284fa84a"

FULL_LINK = 'http://packages.ros.org/ros2/ubuntu/pool/main/r/ros-dashing-cv-bridge/ros-dashing-cv-bridge_2.1.4-1bionic.20201125.103403_arm64.deb'
DEB_NAME = 'ros-dashing-cv-bridge_2.1.4-1bionic.20201125.103403_arm64.deb'
