LICENSE = "Apache-2.0"
SRC_URI[md5sum] = "febfab72aa621fbbde62fe1bb8e223d0"

FULL_LINK = 'http://packages.ros.org/ros2/ubuntu/pool/main/r/ros-dashing-builtin-interfaces/ros-dashing-builtin-interfaces_0.7.4-1bionic.20201125.064356_arm64.deb'
DEB_NAME = 'ros-dashing-builtin-interfaces_0.7.4-1bionic.20201125.064356_arm64.deb'
