LICENSE = "BSD"
SRC_URI[md5sum] = "a990e8ed094c83d54541dfa4c96d41ff"

FULL_LINK = 'http://packages.ros.org/ros2/ubuntu/pool/main/r/ros-dashing-message-filters/ros-dashing-message-filters_3.1.3-1bionic.20210226.193255_arm64.deb'
DEB_NAME = 'ros-dashing-message-filters_3.1.3-1bionic.20210226.193255_arm64.deb'
