inherit native deb-dl

LICENSE = "Apache-2.0"
SRC_URI[md5sum] = "65232e02e4f6bf54ee67f72ecc08bb9e"

FULL_LINK = 'http://packages.ros.org/ros2/ubuntu/pool/main/r/ros-dashing-rosidl-generator-cpp/ros-dashing-rosidl-generator-cpp_0.7.9-1bionic.20200313.203815_arm64.deb'
DEB_NAME = 'ros-dashing-rosidl-generator-cpp_0.7.9-1bionic.20200313.203815_arm64.deb'
