LICENSE = "Apache-2.0"
SRC_URI[md5sum] = "8c9c9f20ea043d84cec03b9363907677"

FULL_LINK = 'http://packages.ros.org/ros2/ubuntu/pool/main/r/ros-dashing-rosidl-typesupport-cpp/ros-dashing-rosidl-typesupport-cpp_0.7.1-1bionic.20201125.063347_arm64.deb'
DEB_NAME = 'ros-dashing-rosidl-typesupport-cpp_0.7.1-1bionic.20201125.063347_arm64.deb'
