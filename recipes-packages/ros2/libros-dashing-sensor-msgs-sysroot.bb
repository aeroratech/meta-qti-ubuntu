inherit native deb-dl

LICENSE = "Apache-2.0"
SRC_URI[md5sum] = "910dc6b9081663f6070a273030f5aa5f"

FULL_LINK = 'http://packages.ros.org/ros2/ubuntu/pool/main/r/ros-dashing-sensor-msgs/ros-dashing-sensor-msgs_0.7.0-1bionic.20200711.100616_arm64.deb'
DEB_NAME = 'ros-dashing-sensor-msgs_0.7.0-1bionic.20200711.100616_arm64.deb'
