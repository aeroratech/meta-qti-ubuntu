LICENSE = "Apache-2.0"
SRC_URI[md5sum] = "2e9b27e70af9cf1e3172fe3f12f5651c"

FULL_LINK = 'http://packages.ros.org/ros2/ubuntu/pool/main/r/ros-dashing-geometry-msgs/ros-dashing-geometry-msgs_0.7.0-1bionic.20201125.080719_arm64.deb'
DEB_NAME = 'ros-dashing-geometry-msgs_0.7.0-1bionic.20201125.080719_arm64.deb'
