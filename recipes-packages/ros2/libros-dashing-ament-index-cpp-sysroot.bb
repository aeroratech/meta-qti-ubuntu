inherit native deb-dl

LICENSE = "Apache-2.0"
SRC_URI[md5sum] = "8828e14c7be08587d52562cff4efc68e"

FULL_LINK = 'http://packages.ros.org/ros2/ubuntu/pool/main/r/ros-dashing-ament-index-cpp/ros-dashing-ament-index-cpp_0.7.2-1bionic.20200711.052304_arm64.deb'
DEB_NAME = 'ros-dashing-ament-index-cpp_0.7.2-1bionic.20200711.052304_arm64.deb'
