inherit native deb-dl

LICENSE = "Apache-2.0"

SRC_URI[md5sum] = "e3b6d24301bcb33b880f147943fd1cfd"

FULL_LINK = 'http://packages.ros.org/ros2/ubuntu/pool/main/r/ros-dashing-rcl/ros-dashing-rcl_0.7.8-1bionic.20200504.222004_arm64.deb'
DEB_NAME = 'ros-dashing-rcl_0.7.8-1bionic.20200504.222004_arm64.deb'
