inherit deb-dl

LICENSE = "GPL-2.0+ & LGPL-2.0+ & BSD-2-clause & MIT"

FULL_LINK = 'http://ports.ubuntu.com/ubuntu-ports/pool/main/g/gobject-introspection/libgirepository-1.0-1_1.64.0-2_arm64.deb'

DEB_NAME = 'libgirepository-1.0-1_1.64.0-2_arm64.deb'

SRC_URI[md5sum] = "8e22eb90913d64731d2f7b2e99abd707"
