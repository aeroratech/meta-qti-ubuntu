inherit deb-dl

LICENSE = "LGPL-2.0+"

FULL_LINK = 'http://ports.ubuntu.com/ubuntu-ports/pool/main/p/pango1.0/libpangoft2-1.0-0_1.44.7-2ubuntu4_arm64.deb'

DEB_NAME = 'libpangoft2-1.0-0_1.44.7-2ubuntu4_arm64.deb'

SRC_URI[md5sum] = "0430dd6ba2143c99760d80966720119f"
