inherit deb-dl

LICENSE = "X11"

FULL_LINK = 'http://ports.ubuntu.com/ubuntu-ports/pool/main/w/wayland/libwayland-egl1_1.18.0-1_arm64.deb'

DEB_NAME = 'libwayland-egl1_1.18.0-1_arm64.deb'

SRC_URI[md5sum] = "ddea0e5db76e33fa2ba61b77e7c69097"
