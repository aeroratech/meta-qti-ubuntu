inherit deb-dl

LICENSE = "LGPL-2.0+ & GPL-2.0+"

FULL_LINK = 'http://ports.ubuntu.com/ubuntu-ports/pool/main/g/gdk-pixbuf/libgdk-pixbuf2.0-bin_2.40.0+dfsg-3_arm64.deb'

DEB_NAME = 'libgdk-pixbuf2.0-bin_2.40.0+dfsg-3_arm64.deb'

SRC_URI[md5sum] = "b5ca1579f96d182140387f4fb8b5d064"
