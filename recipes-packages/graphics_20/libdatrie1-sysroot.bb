inherit deb-dl

LICENSE = "LGPL-2.1+ & GPL-2.0+"

FULL_LINK = 'http://ports.ubuntu.com/ubuntu-ports/pool/main/libd/libdatrie/libdatrie1_0.2.12-3_arm64.deb'

DEB_NAME = 'libdatrie1_0.2.12-3_arm64.deb'

SRC_URI[md5sum] = "ab23afe35672c5296fda6a5f3c844c7d"
