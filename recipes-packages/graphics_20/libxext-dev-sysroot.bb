inherit deb-dl

LICENSE = "MIT-Style"

FULL_LINK = 'http://ports.ubuntu.com/ubuntu-ports/pool/main/libx/libxext/libxext-dev_1.3.4-0ubuntu1_arm64.deb'

DEB_NAME = 'libxext-dev_1.3.4-0ubuntu1_arm64.deb'

SRC_URI[md5sum] = "bab998d667bcfa394dabdf6b5caddc1a"
