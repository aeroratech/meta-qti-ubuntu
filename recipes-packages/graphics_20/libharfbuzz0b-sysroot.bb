inherit deb-dl

LICENSE = "MIT"

FULL_LINK = 'http://ports.ubuntu.com/ubuntu-ports/pool/main/h/harfbuzz/libharfbuzz0b_2.6.4-1ubuntu4_arm64.deb'

DEB_NAME = 'libharfbuzz0b_2.6.4-1ubuntu4_arm64.deb'

SRC_URI[md5sum] = "9d7334b496bd8e141934e032cb789c0b"
