inherit deb-dl

LICENSE = "MIT-Style"

FULL_LINK = 'http://ports.ubuntu.com/ubuntu-ports/pool/main/libx/libxext/libxext6_1.3.4-0ubuntu1_arm64.deb'

DEB_NAME = 'libxext6_1.3.4-0ubuntu1_arm64.deb'

SRC_URI[md5sum] = "300f94cc48e2bef0c26682031a354e97"
