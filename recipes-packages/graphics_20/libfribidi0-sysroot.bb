inherit deb-dl

LICENSE = "LGPL-2.1+"

FULL_LINK = 'http://ports.ubuntu.com/ubuntu-ports/pool/main/f/fribidi/libfribidi0_1.0.8-2_arm64.deb'

DEB_NAME = 'libfribidi0_1.0.8-2_arm64.deb'

SRC_URI[md5sum] = "b6c2ca1ebaae9fb089eb7b59e264efbc"
