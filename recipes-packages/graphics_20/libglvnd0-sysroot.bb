inherit deb-dl

LICENSE = "MIT & Apache-2.0 & PD & GPL-3.0+ & BSD-1-clause& MIT"

FULL_LINK = 'http://ports.ubuntu.com/ubuntu-ports/pool/main/libg/libglvnd/libglvnd0_1.3.1-1_arm64.deb'

DEB_NAME = 'libglvnd0_1.3.1-1_arm64.deb'

SRC_URI[md5sum] = "a1996ba0556ce1187776e3c5776e5a43"
