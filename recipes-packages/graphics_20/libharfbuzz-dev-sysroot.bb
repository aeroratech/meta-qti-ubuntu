inherit deb-dl

LICENSE = "MIT"

FULL_LINK = 'http://ports.ubuntu.com/ubuntu-ports/pool/main/h/harfbuzz/libharfbuzz-dev_2.6.4-1ubuntu4_arm64.deb'

DEB_NAME = 'libharfbuzz-dev_2.6.4-1ubuntu4_arm64.deb'

SRC_URI[md5sum] = "63432e248c79540ad89f876089a0e709"
