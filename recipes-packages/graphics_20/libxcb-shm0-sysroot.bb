inherit deb-dl

LICENSE = "MIT-Style"

FULL_LINK = 'http://ports.ubuntu.com/ubuntu-ports/pool/main/libx/libxcb/libxcb-shm0_1.14-2_arm64.deb'

DEB_NAME = 'libxcb-shm0_1.14-2_arm64.deb'

SRC_URI[md5sum] = "b1c6e2819a29ba642d11215877db1ae6"
