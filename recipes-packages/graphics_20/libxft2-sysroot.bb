inherit deb-dl

LICENSE = "MIT-Style"

FULL_LINK = 'http://ports.ubuntu.com/ubuntu-ports/pool/main/x/xft/libxft2_2.3.3-0ubuntu1_arm64.deb'

DEB_NAME = 'libxft2_2.3.3-0ubuntu1_arm64.deb'

SRC_URI[md5sum] = "331db14912db76c4d2547cd411662aca"
