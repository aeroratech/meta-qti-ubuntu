inherit deb-dl

LICENSE = "FTL | GPL-2.0+"

FULL_LINK = 'http://ports.ubuntu.com/ubuntu-ports/pool/main/f/freetype/libfreetype6-dev_2.10.1-2_arm64.deb'

DEB_NAME = 'libfreetype6-dev_2.10.1-2_arm64.deb'

SRC_URI[md5sum] = "e058563294c86618e823cab0ba602ac1"
