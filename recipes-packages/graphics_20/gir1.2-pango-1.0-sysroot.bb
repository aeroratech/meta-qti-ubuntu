inherit deb-dl

LICENSE = "LGPL-2.0+"

FULL_LINK = 'http://ports.ubuntu.com/ubuntu-ports/pool/main/p/pango1.0/gir1.2-pango-1.0_1.44.7-2ubuntu4_arm64.deb'

DEB_NAME = 'gir1.2-pango-1.0_1.44.7-2ubuntu4_arm64.deb'

SRC_URI[md5sum] = "40a0456736b5d94202adc975e33202e8"
