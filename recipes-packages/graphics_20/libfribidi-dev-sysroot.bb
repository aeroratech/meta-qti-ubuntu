inherit deb-dl

LICENSE = "LGPL-2.1+"

FULL_LINK = 'http://ports.ubuntu.com/ubuntu-ports/pool/main/f/fribidi/libfribidi-dev_1.0.8-2_arm64.deb'

DEB_NAME = 'libfribidi-dev_1.0.8-2_arm64.deb'

SRC_URI[md5sum] = "134d3d2dfe45e60215541f024f31cde6"
