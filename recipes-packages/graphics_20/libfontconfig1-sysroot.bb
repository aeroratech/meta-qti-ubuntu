inherit deb-dl

LICENSE = "MIT-Style"

FULL_LINK = 'http://ports.ubuntu.com/ubuntu-ports/pool/main/f/fontconfig/libfontconfig1_2.13.1-2ubuntu3_arm64.deb'

DEB_NAME = 'libfontconfig1_2.13.1-2ubuntu3_arm64.deb'

SRC_URI[md5sum] = "b782135df14e8c925787a2c8fae1d90f"
