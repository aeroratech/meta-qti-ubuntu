inherit deb-dl

LICENSE = "MIT-Style"

FULL_LINK = 'http://ports.ubuntu.com/ubuntu-ports/pool/main/libx/libxcb/libxcb-shm0-dev_1.14-2_arm64.deb'

DEB_NAME = 'libxcb-shm0-dev_1.14-2_arm64.deb'

SRC_URI[md5sum] = "859f18fabe99dd8e8eadb96bdd989e43"
