inherit deb-dl

LICENSE = "X11"

FULL_LINK = 'http://ports.ubuntu.com/ubuntu-ports/pool/main/w/wayland/libwayland-cursor0_1.18.0-1_arm64.deb'

DEB_NAME = 'libwayland-cursor0_1.18.0-1_arm64.deb'

SRC_URI[md5sum] = "8127c7219cf99a3a123712a3e544fd9c"
