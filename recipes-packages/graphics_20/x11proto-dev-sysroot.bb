inherit deb-dl

LICENSE = "MIT & SGI-B-2.0"

FULL_LINK = 'http://ports.ubuntu.com/ubuntu-ports/pool/main/x/xorgproto/x11proto-dev_2019.2-1ubuntu1_all.deb'

DEB_NAME = 'x11proto-dev_2019.2-1ubuntu1_all.deb'

SRC_URI[md5sum] = "14c605004f0a3597dc21fa10bfe4e129"
