inherit deb-dl

LICENSE = "MIT"

FULL_LINK = 'http://ports.ubuntu.com/ubuntu-ports/pool/main/h/harfbuzz/libharfbuzz-gobject0_2.6.4-1ubuntu4_arm64.deb'

DEB_NAME = 'libharfbuzz-gobject0_2.6.4-1ubuntu4_arm64.deb'

SRC_URI[md5sum] = "2ea80a78fa42b7706be1be907f8e7d24"
