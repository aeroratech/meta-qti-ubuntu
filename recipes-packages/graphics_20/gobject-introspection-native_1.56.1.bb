inherit native


LICENSE = "LGPL-2.0+ & GPL-2.0+ & MIT"

do_install() {
   bbnote install complete;
}
