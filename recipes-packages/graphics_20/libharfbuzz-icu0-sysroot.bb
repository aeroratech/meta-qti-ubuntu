inherit deb-dl

LICENSE = "MIT"

FULL_LINK = 'http://ports.ubuntu.com/ubuntu-ports/pool/main/h/harfbuzz/libharfbuzz-icu0_2.6.4-1ubuntu4_arm64.deb'

DEB_NAME = 'libharfbuzz-icu0_2.6.4-1ubuntu4_arm64.deb'

SRC_URI[md5sum] = "ccc36873cf11209e0a30dfb4acd4929a"
