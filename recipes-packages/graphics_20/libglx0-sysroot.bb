inherit deb-dl

LICENSE = "MIT & Apache-2.0 & PD & GPL-3.0+ & BSD-1-clause& MIT"

FULL_LINK = 'http://ports.ubuntu.com/ubuntu-ports/pool/main/libg/libglvnd/libglx0_1.3.1-1_arm64.deb'

DEB_NAME = 'libglx0_1.3.1-1_arm64.deb'

SRC_URI[md5sum] = "d0b9b36805dbf7c8a2ee5849b9932964"
