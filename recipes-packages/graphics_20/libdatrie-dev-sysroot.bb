inherit deb-dl

LICENSE = "LGPL-2.1+ & GPL-2.0+"

FULL_LINK = 'http://ports.ubuntu.com/ubuntu-ports/pool/main/libd/libdatrie/libdatrie-dev_0.2.12-3_arm64.deb'

DEB_NAME = 'libdatrie-dev_0.2.12-3_arm64.deb'

SRC_URI[md5sum] = "dedf6d08058720c52d6f41f11443831b"
