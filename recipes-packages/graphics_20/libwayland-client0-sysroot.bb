inherit deb-dl

LICENSE = "X11"

FULL_LINK = 'http://ports.ubuntu.com/ubuntu-ports/pool/main/w/wayland/libwayland-client0_1.18.0-1_arm64.deb'

DEB_NAME = 'libwayland-client0_1.18.0-1_arm64.deb'

SRC_URI[md5sum] = "24eab1bf70c3a66d3f5232316c2a7965"
