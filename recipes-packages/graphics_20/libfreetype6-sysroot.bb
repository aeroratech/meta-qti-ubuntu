inherit deb-dl

LICENSE = "FTL | GPL-2.0+"

FULL_LINK = 'http://ports.ubuntu.com/ubuntu-ports/pool/main/f/freetype/libfreetype6_2.10.1-2_arm64.deb'

DEB_NAME = 'libfreetype6_2.10.1-2_arm64.deb'

SRC_URI[md5sum] = "b5ef6ccb4008937e79a8d60dda803f74"
