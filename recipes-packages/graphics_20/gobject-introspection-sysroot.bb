inherit deb-dl

LICENSE = "GPL-2.0+ & LGPL-2.0+ & MIT & BSD-2-clause"

FULL_LINK = 'http://ports.ubuntu.com/ubuntu-ports/pool/main/g/gobject-introspection/gobject-introspection_1.64.0-2_arm64.deb'

DEB_NAME = 'gobject-introspection_1.64.0-2_arm64.deb'

SRC_URI[md5sum] = "6acf1c7bd8d37f79bf5fe44e6f3eaee2"
