inherit deb-dl

LICENSE = "LGPL-2.0+"

FULL_LINK = 'http://ports.ubuntu.com/ubuntu-ports/pool/main/p/pango1.0/libpango-1.0-0_1.44.7-2ubuntu4_arm64.deb'

DEB_NAME = 'libpango-1.0-0_1.44.7-2ubuntu4_arm64.deb'

SRC_URI[md5sum] = "02196c3ff090cb5c2df93e35e82f6a10"
