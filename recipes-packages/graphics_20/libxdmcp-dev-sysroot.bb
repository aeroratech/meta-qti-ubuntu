inherit deb-dl

LICENSE = "MIT-Style"

FULL_LINK = 'http://ports.ubuntu.com/ubuntu-ports/pool/main/libx/libxdmcp/libxdmcp-dev_1.1.3-0ubuntu1_arm64.deb'

DEB_NAME = 'libxdmcp-dev_1.1.3-0ubuntu1_arm64.deb'

SRC_URI[md5sum] = "c9d9176c053f7bd343e18bd128cf2e1a"
