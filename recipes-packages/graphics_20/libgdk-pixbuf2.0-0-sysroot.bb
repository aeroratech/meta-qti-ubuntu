inherit deb-dl

LICENSE = "LGPL-2.0+ & GPL-2.0+"

FULL_LINK = 'http://ports.ubuntu.com/ubuntu-ports/pool/main/g/gdk-pixbuf/libgdk-pixbuf2.0-0_2.40.0+dfsg-3_arm64.deb'

DEB_NAME = 'libgdk-pixbuf2.0-0_2.40.0+dfsg-3_arm64.deb'

SRC_URI[md5sum] = "7b76e401725983ce498514e4d83698ef"
