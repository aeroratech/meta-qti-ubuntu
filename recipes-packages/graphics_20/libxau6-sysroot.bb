inherit deb-dl

LICENSE = "MIT-Style"

FULL_LINK = 'http://ports.ubuntu.com/ubuntu-ports/pool/main/libx/libxau/libxau6_1.0.9-0ubuntu1_arm64.deb'

DEB_NAME = 'libxau6_1.0.9-0ubuntu1_arm64.deb'

SRC_URI[md5sum] = "778330b2b0b397dd782751e54288304a"
