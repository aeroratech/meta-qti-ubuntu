inherit deb-dl

LICENSE = "Apache-2.0"

FULL_LINK = 'http://ports.ubuntu.com/ubuntu-ports/pool/universe/t/tbb/libtbb-dev_2020.1-2_arm64.deb'

DEB_NAME = 'libtbb-dev_2020.1-2_arm64.deb'

SRC_URI[md5sum] = "a0711f2acf4dfd7b34c8a1171bbb2319"
