inherit deb-dl

LICENSE = "LGPL-2.1 | MPL-1.1 & MIT-Style"

FULL_LINK = 'http://ports.ubuntu.com/ubuntu-ports/pool/main/c/cairo/libcairo-script-interpreter2_1.16.0-4ubuntu1_arm64.deb'

DEB_NAME = 'libcairo-script-interpreter2_1.16.0-4ubuntu1_arm64.deb'

SRC_URI[md5sum] = "7042ae4a7899c60e93fbdf94fd931715"
