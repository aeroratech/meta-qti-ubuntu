inherit deb-dl

LICENSE = "LGPL-2.0+"

FULL_LINK = 'http://ports.ubuntu.com/ubuntu-ports/pool/main/p/pango1.0/libpango1.0-dev_1.44.7-2ubuntu4_arm64.deb'

DEB_NAME = 'libpango1.0-dev_1.44.7-2ubuntu4_arm64.deb'

SRC_URI[md5sum] = "e9bcb5013ba5beac73c9ce9e7607b3c0"
