inherit deb-dl

LICENSE = "Various licenses"

#LIC_FILES_CHKSUM = "\
#    file://https://changelogs.ubuntu.com/changelogs/pool/main/libx/libx11/libx11_1.6.9-2ubuntu1.2/copyright;md5=6121e1d103eb0c51500be21cdd73e4b4 \
#"

FULL_LINK = 'http://ports.ubuntu.com/ubuntu-ports/pool/main/libx/libx11/libx11-xcb1_1.6.9-2ubuntu1_arm64.deb'

DEB_NAME = 'libx11-xcb1_1.6.9-2ubuntu1_arm64.deb'

SRC_URI[md5sum] = "b04e56f5b8ddef3d0d304c5df4ca5b37"
