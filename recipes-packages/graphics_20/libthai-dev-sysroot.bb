inherit deb-dl

LICENSE = "LGPL-2.1+ & GPL-2.0+"

FULL_LINK = 'http://ports.ubuntu.com/ubuntu-ports/pool/main/libt/libthai/libthai-dev_0.1.28-3_arm64.deb'

DEB_NAME = 'libthai-dev_0.1.28-3_arm64.deb'

SRC_URI[md5sum] = "6937041cb80d38e8277fe0b0cd0aa0bc"
