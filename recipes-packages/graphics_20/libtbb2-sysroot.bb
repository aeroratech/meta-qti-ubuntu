inherit deb-dl

LICENSE = "Apache-2.0"

FULL_LINK = 'http://ports.ubuntu.com/ubuntu-ports/pool/universe/t/tbb/libtbb2_2020.1-2_arm64.deb'

DEB_NAME = 'libtbb2_2020.1-2_arm64.deb'

SRC_URI[md5sum] = "93d611bf9d86c9338277316a25ec02f3"
