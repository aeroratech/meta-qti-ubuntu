inherit deb-dl

LICENSE = "X11"

FULL_LINK = 'http://ports.ubuntu.com/ubuntu-ports/pool/main/w/wayland/libwayland-server0_1.18.0-1_arm64.deb'

DEB_NAME = 'libwayland-server0_1.18.0-1_arm64.deb'

SRC_URI[md5sum] = "00fe80e82612ee246f6f07b063f79629"
