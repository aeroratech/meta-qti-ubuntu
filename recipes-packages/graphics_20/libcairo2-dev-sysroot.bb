inherit deb-dl

LICENSE = "LGPL-2.1 | MPL-1.1 & MIT-Style"

FULL_LINK = 'http://ports.ubuntu.com/ubuntu-ports/pool/main/c/cairo/libcairo2-dev_1.16.0-4ubuntu1_arm64.deb'

DEB_NAME = 'libcairo2-dev_1.16.0-4ubuntu1_arm64.deb'

SRC_URI[md5sum] = "22d08f944b46b6ec7ccb84293cff5906"
