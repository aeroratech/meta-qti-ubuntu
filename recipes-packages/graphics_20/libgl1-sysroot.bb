inherit deb-dl

LICENSE = "MIT & Apache-2.0 & PD & GPL-3.0+ & BSD-1-clause& MIT"

FULL_LINK = 'http://ports.ubuntu.com/ubuntu-ports/pool/main/libg/libglvnd/libgl1_1.3.1-1_arm64.deb'

DEB_NAME = 'libgl1_1.3.1-1_arm64.deb'

SRC_URI[md5sum] = "a96b6d304878576a061b96e119bf33c4"
