inherit deb-dl

LICENSE = "MIT & Apache-2.0 & PD & GPL-3.0+ & BSD-1-clause& MIT"

FULL_LINK = 'http://ports.ubuntu.com/ubuntu-ports/pool/main/libg/libglvnd/libgl-dev_1.3.1-1_arm64.deb'

DEB_NAME = 'libgl-dev_1.3.1-1_arm64.deb'

SRC_URI[md5sum] = "a7d8f842b6b78597afd41c99eb02d4ae"
