inherit deb-dl

LICENSE = "LGPL-2.0+"

FULL_LINK = 'http://ports.ubuntu.com/ubuntu-ports/pool/main/p/pango1.0/libpangoxft-1.0-0_1.44.7-2ubuntu4_arm64.deb'

DEB_NAME = 'libpangoxft-1.0-0_1.44.7-2ubuntu4_arm64.deb'

SRC_URI[md5sum] = "a0a4abe52e40a016e5a04b98d1d77064"
