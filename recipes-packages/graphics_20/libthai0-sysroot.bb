inherit deb-dl

LICENSE = "LGPL-2.1+ & GPL-2.0+"

FULL_LINK = 'http://ports.ubuntu.com/ubuntu-ports/pool/main/libt/libthai/libthai0_0.1.28-3_arm64.deb'

DEB_NAME = 'libthai0_0.1.28-3_arm64.deb'

SRC_URI[md5sum] = "86dc6c3d1601f1c42ad4f79d026300a8"
