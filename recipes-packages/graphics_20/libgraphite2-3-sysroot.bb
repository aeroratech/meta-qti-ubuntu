inherit deb-dl

LICENSE = "LGPL-2.1+ | MPL-1.1 | GPL-2.0+"

FULL_LINK = 'http://ports.ubuntu.com/ubuntu-ports/pool/main/g/graphite2/libgraphite2-3_1.3.13-11build1_arm64.deb'

DEB_NAME = 'libgraphite2-3_1.3.13-11build1_arm64.deb'

SRC_URI[md5sum] = "3bb6331fdcffdd560d8e9940705aef68"
