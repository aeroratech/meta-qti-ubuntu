inherit deb-dl

LICENSE = "MIT"

FULL_LINK = 'http://ports.ubuntu.com/ubuntu-ports/pool/main/libx/libxcb/libxcb-render0_1.14-2_arm64.deb'

DEB_NAME = 'libxcb-render0_1.14-2_arm64.deb'

SRC_URI[md5sum] = "2c11fd67ca15a5f1870fb6b4a7e0b00a"
