inherit deb-dl

LICENSE = "MIT-Style"

FULL_LINK = 'http://ports.ubuntu.com/ubuntu-ports/pool/main/libx/libxdmcp/libxdmcp6_1.1.3-0ubuntu1_arm64.deb'

DEB_NAME = 'libxdmcp6_1.1.3-0ubuntu1_arm64.deb'

SRC_URI[md5sum] = "1a87759bc2d4199db6514afbe46057ba"
