inherit deb-dl

LICENSE = "MIT-Style"

FULL_LINK = 'http://ports.ubuntu.com/ubuntu-ports/pool/main/f/fontconfig/libfontconfig1-dev_2.13.1-2ubuntu3_arm64.deb'

DEB_NAME = 'libfontconfig1-dev_2.13.1-2ubuntu3_arm64.deb'

SRC_URI[md5sum] = "5a34f5c3763d8e04f9737d25794e8872"
