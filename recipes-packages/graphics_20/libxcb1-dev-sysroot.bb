inherit deb-dl

LICENSE = "MIT-Style"

FULL_LINK = 'http://ports.ubuntu.com/ubuntu-ports/pool/main/libx/libxcb/libxcb1-dev_1.14-2_arm64.deb'

DEB_NAME = 'libxcb1-dev_1.14-2_arm64.deb'

SRC_URI[md5sum] = "3928f69de7670a907f1507a233189525"
