inherit deb-dl

LICENSE = "MIT-Style"

FULL_LINK = 'http://ports.ubuntu.com/ubuntu-ports/pool/main/libx/libxau/libxau-dev_1.0.9-0ubuntu1_arm64.deb'

DEB_NAME = 'libxau-dev_1.0.9-0ubuntu1_arm64.deb'

SRC_URI[md5sum] = "289b8a8490eb702dafc76a96fadd0c5d"
