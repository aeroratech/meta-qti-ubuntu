inherit deb-dl

LICENSE = "MIT-Style"

FULL_LINK = 'http://ports.ubuntu.com/ubuntu-ports/pool/main/x/xft/libxft-dev_2.3.3-0ubuntu1_arm64.deb'

DEB_NAME = 'libxft-dev_2.3.3-0ubuntu1_arm64.deb'

SRC_URI[md5sum] = "15185819505e857a0a324375f99fdf4b"
