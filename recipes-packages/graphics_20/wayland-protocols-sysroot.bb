inherit deb-dl

LICENSE = "MIT"

FULL_LINK = 'http://ports.ubuntu.com/ubuntu-ports/pool/main/w/wayland-protocols/wayland-protocols_1.20-1_all.deb'

DEB_NAME = 'wayland-protocols_1.20-1_all.deb'

SRC_URI[md5sum] = "c3187b9e195114969dbc56a46765ee6d"
