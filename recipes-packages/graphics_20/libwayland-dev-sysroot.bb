inherit deb-dl

LICENSE = "X11"

FULL_LINK = 'http://ports.ubuntu.com/ubuntu-ports/pool/main/w/wayland/libwayland-dev_1.18.0-1_arm64.deb'

DEB_NAME = 'libwayland-dev_1.18.0-1_arm64.deb'

SRC_URI[md5sum] = "c9f3b55ad0fbca47f78fb003cb0a9327"
