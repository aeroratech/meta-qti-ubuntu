inherit deb-dl

LICENSE = "MIT"

FULL_LINK = 'http://ports.ubuntu.com/ubuntu-ports/pool/main/libx/libxcb/libxcb1_1.14-2_arm64.deb'

DEB_NAME = 'libxcb1_1.14-2_arm64.deb'

SRC_URI[md5sum] = "16b9dc33cdb8d34cc3de05579f500f64"
