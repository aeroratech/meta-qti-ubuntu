inherit deb-dl

LICENSE = "MIT"

FULL_LINK = 'http://ports.ubuntu.com/ubuntu-ports/pool/main/libx/libxcb/libxcb-render0-dev_1.14-2_arm64.deb'

DEB_NAME = 'libxcb-render0-dev_1.14-2_arm64.deb'

SRC_URI[md5sum] = "ab60ef867db6b3bda7b8e4b3e301f3df"
