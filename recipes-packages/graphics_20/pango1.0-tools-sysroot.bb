inherit deb-dl

LICENSE = "LGPL-2.0+"

FULL_LINK = 'http://ports.ubuntu.com/ubuntu-ports/pool/main/p/pango1.0/pango1.0-tools_1.44.7-2ubuntu4_arm64.deb'

DEB_NAME = 'pango1.0-tools_1.44.7-2ubuntu4_arm64.deb'

SRC_URI[md5sum] = "334c15705f4a12206627e65ead46f150"
