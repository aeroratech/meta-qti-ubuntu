inherit deb-dl

LICENSE = "LGPL-2.0+"

FULL_LINK = 'http://ports.ubuntu.com/ubuntu-ports/pool/main/p/pango1.0/libpangocairo-1.0-0_1.44.7-2ubuntu4_arm64.deb'

DEB_NAME = 'libpangocairo-1.0-0_1.44.7-2ubuntu4_arm64.deb'

SRC_URI[md5sum] = "01b15a11930a464d7b62ec349533af0d"
