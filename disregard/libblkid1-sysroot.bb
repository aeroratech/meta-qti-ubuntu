inherit native deb-dl

LICENSE = "GPLv2+ & LGPLv2.1+ & BSD-3-Clause & BSD-4-Clause & MIT & PD"

SRC_URI[md5sum] = "868ce3ccf01ed899b69cf97da2c0d29e"

FULL_LINK = 'http://security.ubuntu.com/ubuntu/pool/main/u/util-linux/libblkid1_2.31.1-0.4ubuntu3_amd64.deb'
DEB_NAME = 'libblkid1_2.31.1-0.4ubuntu3_amd64.deb'
