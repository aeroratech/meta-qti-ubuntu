inherit native deb-dl

LICENSE = "EPL-1.0"

SRC_URI[md5sum] = "999bd46052b2d51824f0fa7462e54caa"

FULL_LINK = 'http://security.ubuntu.com/ubuntu/pool/main/g/gcc-7-cross/cpp-7-aarch64-linux-gnu_7.5.0-3ubuntu1~18.04cross1_amd64.deb'
DEB_NAME = 'cpp-7-aarch64-linux-gnu_7.5.0-3ubuntu1~18.04cross1_amd64.deb'
