LICENSE = "Apache-2.0"
SRC_URI[md5sum] = "f05dfde395fa8903045f1b8ec6a3a134"

FULL_LINK = 'http://packages.ros.org/ros2/ubuntu/pool/main/r/ros-foxy-rosidl-typesupport-c/ros-foxy-rosidl-typesupport-c_1.0.2-1focal.20220115.051647_arm64.deb'
DEB_NAME = 'ros-foxy-rosidl-typesupport-c_1.0.2-1focal.20220115.051647_arm64.deb'
