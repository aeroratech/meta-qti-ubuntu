LICENSE = "Apache-2.0"
SRC_URI[md5sum] = "5eafbc700e7eef61867b5d1ffa4c8f79"

FULL_LINK = 'http://packages.ros.org/ros2/ubuntu/pool/main/r/ros-foxy-rosidl-generator-c/ros-foxy-rosidl-generator-c_1.2.1-1focal.20220115.045952_arm64.deb'
DEB_NAME = 'ros-foxy-rosidl-generator-c_1.2.1-1focal.20220115.045952_arm64.deb'
