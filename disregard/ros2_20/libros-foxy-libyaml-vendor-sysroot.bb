LICENSE = "MIT & Apache-2.0"

SRC_URI[md5sum] = "09a4ce0c154f95910b055792adb3793d"

FULL_LINK = 'http://packages.ros.org/ros2/ubuntu/pool/main/r/ros-foxy-libyaml-vendor/ros-foxy-libyaml-vendor_1.0.4-1focal.20220115.045425_arm64.deb'
DEB_NAME = 'ros-foxy-libyaml-vendor_1.0.4-1focal.20220115.045425_arm64.deb'
