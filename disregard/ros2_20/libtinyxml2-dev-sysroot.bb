inherit deb-dl

LICENSE = "Zlib & GPL-2.0+"

FULL_LINK = 'http://ports.ubuntu.com/ubuntu-ports/pool/universe/t/tinyxml2/libtinyxml2-dev_7.0.0+dfsg-1build1_arm64.deb'

DEB_NAME = 'libtinyxml2-dev_7.0.0+dfsg-1build1_arm64.deb'

SRC_URI[md5sum] = "c79d213f414dd22fae513b93c05140af"
