LICENSE = "Apache-2.0"

SRC_URI[md5sum] = "f55113d97b1cc4bb242f9d9c8921f8cb"

FULL_LINK = 'http://packages.ros.org/ros2/ubuntu/pool/main/r/ros-foxy-builtin-interfaces/ros-foxy-builtin-interfaces_1.0.0-1focal.20220209.135951_arm64.deb'
DEB_NAME = 'ros-foxy-builtin-interfaces_1.0.0-1focal.20220209.135951_arm64.deb'
