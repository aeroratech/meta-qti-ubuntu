LICENSE = "BSD"
SRC_URI[md5sum] = "fea0ec82cab26c55e995b2a6eae3828e"

FULL_LINK = 'http://packages.ros.org/ros2/ubuntu/pool/main/r/ros-foxy-class-loader/ros-foxy-class-loader_2.0.2-1focal.20220115.051315_arm64.deb'
DEB_NAME = 'ros-foxy-class-loader_2.0.2-1focal.20220115.051315_arm64.deb'
