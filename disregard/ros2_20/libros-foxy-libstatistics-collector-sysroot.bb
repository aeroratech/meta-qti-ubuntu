LICENSE = "Apache-2.0"
SRC_URI[md5sum] = "43bcd50284dca1d69e6697bcfbc8cbf7"

FULL_LINK = 'http://packages.ros.org/ros2/ubuntu/pool/main/r/ros-foxy-libstatistics-collector/ros-foxy-libstatistics-collector_1.0.1-1focal.20220209.144425_arm64.deb'
DEB_NAME = 'ros-foxy-libstatistics-collector_1.0.1-1focal.20220209.144425_arm64.deb'
