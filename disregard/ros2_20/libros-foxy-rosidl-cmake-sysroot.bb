LICENSE = "Apache-2.0"
SRC_URI[md5sum] = "6ca0de8f29768a63ff1f855a84211e8a"

FULL_LINK = 'http://packages.ros.org/ros2/ubuntu/pool/main/r/ros-foxy-rosidl-cmake/ros-foxy-rosidl-cmake_1.2.1-1focal.20210901.054905_arm64.deb'
DEB_NAME = 'ros-foxy-rosidl-cmake_1.2.1-1focal.20210901.054905_arm64.deb'
