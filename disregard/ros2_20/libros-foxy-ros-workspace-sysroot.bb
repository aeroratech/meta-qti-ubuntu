LICENSE = "Apache-2.0"
SRC_URI[md5sum] = "56e4403ba0d995d81bf1623c51bdfd58"

FULL_LINK = 'http://packages.ros.org/ros2/ubuntu/pool/main/r/ros-foxy-ros-workspace/ros-foxy-ros-workspace_1.0.1-1focal.20210901.015945_arm64.deb'
DEB_NAME = 'ros-foxy-ros-workspace_1.0.1-1focal.20210901.015945_arm64.deb'
