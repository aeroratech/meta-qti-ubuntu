LICENSE = "Apache-2.0"

FULL_LINK = 'http://packages.ros.org/ros2/ubuntu/pool/main/r/ros-foxy-nav-msgs/ros-foxy-nav-msgs_2.0.5-1focal.20220209.141851_arm64.deb'
DEB_NAME = 'ros-foxy-nav-msgs_2.0.5-1focal.20220209.141851_arm64.deb'

SRC_URI[md5sum] = "23c7801ee51161e9750601de9707d90e"
