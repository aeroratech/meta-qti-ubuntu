LICENSE = "Apache-2.0"
SRC_URI[md5sum] = "f7d039d9cd9d3adf781a644c93c8f615"

FULL_LINK = 'http://packages.ros.org/ros2/ubuntu/pool/main/r/ros-foxy-rclcpp/ros-foxy-rclcpp_2.4.1-1focal.20220209.144734_arm64.deb'
DEB_NAME = 'ros-foxy-rclcpp_2.4.1-1focal.20220209.144734_arm64.deb'
