LICENSE = "Apache-2.0"
SRC_URI[md5sum] = "8e0939b95cb3b1c3d9136d24ca4fca1a"

FULL_LINK = 'http://packages.ros.org/ros2/ubuntu/pool/main/r/ros-foxy-tracetools/ros-foxy-tracetools_1.0.5-2focal.20210901.051355_arm64.deb'
DEB_NAME = 'ros-foxy-tracetools_1.0.5-2focal.20210901.051355_arm64.deb'
