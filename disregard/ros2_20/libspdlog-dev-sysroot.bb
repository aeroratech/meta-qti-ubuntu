inherit deb-dl

LICENSE = "MIT & BSD-2-clause"

FULL_LINK = 'http://ports.ubuntu.com/ubuntu-ports/pool/universe/s/spdlog/libspdlog-dev_1.5.0-1_arm64.deb'

DEB_NAME = 'libspdlog-dev_1.5.0-1_arm64.deb'

SRC_URI[md5sum] = "b8423627add63a13a93fecce02319337"
