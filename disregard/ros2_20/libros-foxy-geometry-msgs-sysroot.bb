LICENSE = "Apache-2.0"

SRC_URI[md5sum] = "d4081b9a31507184819822686a5755a8"
FULL_LINK = 'http://packages.ros.org/ros2/ubuntu/pool/main/r/ros-foxy-geometry-msgs/ros-foxy-geometry-msgs_2.0.5-1focal.20220209.141546_arm64.deb'
DEB_NAME = 'ros-foxy-geometry-msgs_2.0.5-1focal.20220209.141546_arm64.deb'
