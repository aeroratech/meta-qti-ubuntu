LICENSE = "Apache-2.0"
SRC_URI[md5sum] = "88c892143105a9d443ec64727ed3f8f3"

FULL_LINK = 'http://packages.ros.org/ros2/ubuntu/pool/main/r/ros-foxy-rosidl-typesupport-cpp/ros-foxy-rosidl-typesupport-cpp_1.0.2-1focal.20220115.053519_arm64.deb'
DEB_NAME = 'ros-foxy-rosidl-typesupport-cpp_1.0.2-1focal.20220115.053519_arm64.deb'
