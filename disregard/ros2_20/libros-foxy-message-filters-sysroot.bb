LICENSE = "BSD"
SRC_URI[md5sum] = "ba8ea9362b5f04b0abbf66d566fcdcba"

FULL_LINK = 'http://packages.ros.org/ros2/ubuntu/pool/main/r/ros-foxy-message-filters/ros-foxy-message-filters_3.2.5-1focal.20220209.150909_arm64.deb'
DEB_NAME = 'ros-foxy-message-filters_3.2.5-1focal.20220209.150909_arm64.deb'
