LICENSE = "Apache-2.0"
SRC_URI[md5sum] = "250a1542e190f87941a7abade1028398"

FULL_LINK = 'http://packages.ros.org/ros2/ubuntu/pool/main/r/ros-foxy-rosidl-typesupport-introspection-c/ros-foxy-rosidl-typesupport-introspection-c_1.2.1-1focal.20220115.050325_arm64.deb'
DEB_NAME = 'ros-foxy-rosidl-typesupport-introspection-c_1.2.1-1focal.20220115.050325_arm64.deb'
