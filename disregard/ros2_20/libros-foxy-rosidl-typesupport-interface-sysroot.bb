LICENSE = "Apache-2.0"
SRC_URI[md5sum] = "28ccf6ae6b46c64332210d0f8ee64b33"

FULL_LINK = 'http://packages.ros.org/ros2/ubuntu/pool/main/r/ros-foxy-rosidl-typesupport-interface/ros-foxy-rosidl-typesupport-interface_1.2.1-1focal.20210901.054738_arm64.deb'
DEB_NAME = 'ros-foxy-rosidl-typesupport-interface_1.2.1-1focal.20210901.054738_arm64.deb'
