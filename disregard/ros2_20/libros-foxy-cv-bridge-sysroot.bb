LICENSE = "BSD"
SRC_URI[md5sum] = "4307a4f60831dcad5c9a60737173345b"

FULL_LINK = 'http://packages.ros.org/ros2/ubuntu/pool/main/r/ros-foxy-cv-bridge/ros-foxy-cv-bridge_2.2.1-1focal.20220209.144047_arm64.deb'
DEB_NAME = 'ros-foxy-cv-bridge_2.2.1-1focal.20220209.144047_arm64.deb'
