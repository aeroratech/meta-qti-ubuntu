inherit deb-dl

LICENSE = "Zlib & GPL-2.0+"

FULL_LINK = 'http://ports.ubuntu.com/ubuntu-ports/pool/universe/t/tinyxml2/libtinyxml2-6a_7.0.0+dfsg-1build1_arm64.deb'

DEB_NAME = 'libtinyxml2-6a_7.0.0+dfsg-1build1_arm64.deb'

SRC_URI[md5sum] = "2e94e151977cf13183d734fd3ca454d2"
