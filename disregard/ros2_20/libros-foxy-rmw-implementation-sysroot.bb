LICENSE = "Apache-2.0"
SRC_URI[md5sum] = "f1a22836418a6b1ea942f99ac727d6b0"

FULL_LINK = 'http://packages.ros.org/ros2/ubuntu/pool/main/r/ros-foxy-rmw-implementation/ros-foxy-rmw-implementation_1.0.3-1focal.20220209.143649_arm64.deb'
DEB_NAME = 'ros-foxy-rmw-implementation_1.0.3-1focal.20220209.143649_arm64.deb'
