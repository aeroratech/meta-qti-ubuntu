LICENSE = "Apache-2.0"
SRC_URI[md5sum] = "7750026bb4982bad03c4dd39798f3fe7"

FULL_LINK = 'http://packages.ros.org/ros2/ubuntu/pool/main/r/ros-foxy-std-msgs/ros-foxy-std-msgs_2.0.5-1focal.20220209.140708_arm64.deb'
DEB_NAME = 'ros-foxy-std-msgs_2.0.5-1focal.20220209.140708_arm64.deb'
