
LICENSE = "Apache-2.0"

FULL_LINK = 'http://packages.ros.org/ros2/ubuntu/pool/main/r/ros-foxy-ament-package/ros-foxy-ament-package_0.9.5-1focal.20210422.231141_arm64.deb'
DEB_NAME = 'ros-foxy-ament-package_0.9.5-1focal.20210422.231141_arm64.deb'

SRC_URI[md5sum] = "be890fb00c3f059182b93929a8ca722f"
