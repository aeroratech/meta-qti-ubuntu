LICENSE = "Apache-2.0"
SRC_URI[md5sum] = "1b0edb7f96ce0079d34705b4bccdc4d8"

FULL_LINK = 'http://packages.ros.org/ros2/ubuntu/pool/main/r/ros-foxy-rcl-yaml-param-parser/ros-foxy-rcl-yaml-param-parser_1.1.13-1focal.20220204.165602_arm64.deb'
DEB_NAME = 'ros-foxy-rcl-yaml-param-parser_1.1.13-1focal.20220204.165602_arm64.deb'
