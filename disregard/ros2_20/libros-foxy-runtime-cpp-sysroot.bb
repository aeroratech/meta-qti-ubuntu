LICENSE = "Apache-2.0"
SRC_URI[md5sum] = "a3dd77385a2739d78563e0af77ebcf02"

FULL_LINK = 'http://packages.ros.org/ros2/ubuntu/pool/main/r/ros-foxy-rosidl-runtime-cpp/ros-foxy-rosidl-runtime-cpp_1.2.1-1focal.20220115.045431_arm64.deb'
DEB_NAME = 'ros-foxy-rosidl-runtime-cpp_1.2.1-1focal.20220115.045431_arm64.deb'
