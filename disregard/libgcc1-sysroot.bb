inherit native deb-dl

LICENSE = "GPL-3.0-with-GCC-exception & GPLv3"

FULL_LINK = 'http://security.ubuntu.com/ubuntu/pool/main/g/gcc-8/libgcc1_8.3.0-26ubuntu1~18.04_amd64.deb'
DEB_NAME = 'libgcc1_8.3.0-26ubuntu1~18.04_amd64.deb'
SRC_URI[md5sum] = "d0147429fbf7897937444f75488b86f3"
