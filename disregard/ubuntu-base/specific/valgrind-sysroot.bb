inherit deb-dl

LICENSE = "GPL-2.0+"

FULL_LINK = 'http://ports.ubuntu.com/ubuntu-ports/pool/main/v/valgrind/valgrind_3.15.0-1ubuntu9_arm64.deb'

DEB_NAME = 'valgrind_3.15.0-1ubuntu9_arm64.deb'

SRC_URI[md5sum] = "24fb173dba68253a07472d27ec3846f8"

