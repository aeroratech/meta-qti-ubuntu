inherit deb-dl

LICENSE = "LGPL-2.1+ & GPL-2.0+"

FULL_LINK = 'http://ports.ubuntu.com/ubuntu-ports/pool/main/p/procps/procps_3.3.16-1ubuntu2_arm64.deb'

DEB_NAME = 'procps_3.3.16-1ubuntu2_arm64.deb'

SRC_URI[md5sum] = "2fdf319ed688220e60ea04365badd907"

