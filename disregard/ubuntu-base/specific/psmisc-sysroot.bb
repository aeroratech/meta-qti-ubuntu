inherit deb-dl

LICENSE = "GPL-2.0+"

FULL_LINK = 'http://ports.ubuntu.com/ubuntu-ports/pool/main/p/psmisc/psmisc_23.3-1_arm64.deb'

DEB_NAME = 'psmisc_23.3-1_arm64.deb'

SRC_URI[md5sum] = "7480cb7c0c099f28cf340b01e0978227"

