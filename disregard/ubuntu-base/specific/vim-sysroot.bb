inherit deb-dl

LICENSE = "Vim"

FULL_LINK = 'http://ports.ubuntu.com/ubuntu-ports/pool/main/v/vim/vim_8.1.2269-1ubuntu5_arm64.deb'

DEB_NAME = 'vim_8.1.2269-1ubuntu5_arm64.deb'

SRC_URI[md5sum] = "e89f1e161b5d01d38a41012220e14116"

