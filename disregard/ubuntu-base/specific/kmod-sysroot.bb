inherit deb-dl

LICENSE = "GPL-2.0+ & LGPL-2.1+"

FULL_LINK = 'http://ports.ubuntu.com/ubuntu-ports/pool/main/k/kmod/kmod_27-1ubuntu2_arm64.deb'

DEB_NAME = 'kmod_27-1ubuntu2_arm64.deb'

SRC_URI[md5sum] = "b91d18f4dbff1a6b8a26c2e6c4388732"

