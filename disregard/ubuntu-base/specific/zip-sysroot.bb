inherit deb-dl

LICENSE = "Info-ZIP"

FULL_LINK = 'http://ports.ubuntu.com/ubuntu-ports/pool/main/z/zip/zip_3.0-11build1_arm64.deb'

DEB_NAME = 'zip_3.0-11build1_arm64.deb'

SRC_URI[md5sum] = "d152ab1f95b9f92ea21310f5810c9e13"

