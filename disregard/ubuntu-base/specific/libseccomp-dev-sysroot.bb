inherit deb-dl

LICENSE = "LGPL-2.1"

FULL_LINK = 'http://ports.ubuntu.com/ubuntu-ports/pool/main/libs/libseccomp/libseccomp-dev_2.4.3-1ubuntu1_arm64.deb'

DEB_NAME = 'libseccomp-dev_2.4.3-1ubuntu1_arm64.deb'

SRC_URI[md5sum] = "01730e8fa50f464f13b337cc9ae1eea8"

