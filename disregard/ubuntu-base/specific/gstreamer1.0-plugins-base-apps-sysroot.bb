inherit deb-dl

LICENSE = "LGPL-2.0+ & MIT & BSD-3-Clause"

FULL_LINK = 'http://ports.ubuntu.com/ubuntu-ports/pool/main/g/gst-plugins-base1.0/gstreamer1.0-plugins-base-apps_1.16.2-4_arm64.deb'

DEB_NAME = 'gstreamer1.0-plugins-base-apps_1.16.2-4_arm64.deb'

SRC_URI[md5sum] = "3b45e4fbf7f2411996fb885a3869eae9"

