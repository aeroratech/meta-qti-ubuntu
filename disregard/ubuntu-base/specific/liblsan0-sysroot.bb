inherit deb-dl

LICENSE = "BSD-3-Clause & MIT"

FULL_LINK = 'http://ports.ubuntu.com/ubuntu-ports/pool/main/g/gcc-10/liblsan0_10-20200411-0ubuntu1_arm64.deb'

DEB_NAME = 'liblsan0_10-20200411-0ubuntu1_arm64.deb'

SRC_URI[md5sum] = "7d12b91f7f10490416452c73b87ccab7"

