inherit deb-dl

LICENSE = "LGPL-2.0+ & LGPL-2.1+"

FULL_LINK = 'http://ports.ubuntu.com/ubuntu-ports/pool/universe/g/gst-libav1.0/gstreamer1.0-libav_1.16.2-2_arm64.deb'

DEB_NAME = 'gstreamer1.0-libav_1.16.2-2_arm64.deb'

SRC_URI[md5sum] = "95af9be488b9d6da12b1ddd312f77400"

