inherit deb-dl

LICENSE = "GPL-3.0+"

FULL_LINK = 'http://ports.ubuntu.com/ubuntu-ports/pool/universe/i/inetutils/inetutils-ping_1.9.4-11_arm64.deb'

DEB_NAME = 'inetutils-ping_1.9.4-11_arm64.deb'

SRC_URI[md5sum] = "37bdd2307a37b1071872167321ed5d01"

