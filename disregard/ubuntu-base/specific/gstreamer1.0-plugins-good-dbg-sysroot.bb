inherit deb-dl

LICENSE = "LGPL-2.0+ & LGPL-2.1+ & MIT & BSD"

FULL_LINK = 'http://ports.ubuntu.com/ubuntu-ports/pool/universe/g/gst-plugins-good1.0/gstreamer1.0-plugins-good-dbg_1.16.2-1ubuntu2_arm64.deb'

DEB_NAME = 'gstreamer1.0-plugins-good-dbg_1.16.2-1ubuntu2_arm64.deb'

SRC_URI[md5sum] = "9c9deede1676c5ddd6e6e94a6bed2037"

