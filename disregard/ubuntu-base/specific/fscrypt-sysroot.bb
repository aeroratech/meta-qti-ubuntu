inherit deb-dl

LICENSE = "Apache-2.0"

FULL_LINK = 'http://ports.ubuntu.com/ubuntu-ports/pool/universe/f/fscrypt/fscrypt_0.2.5-2_arm64.deb'

DEB_NAME = 'fscrypt_0.2.5-2_arm64.deb'

SRC_URI[md5sum] = "e023dbeefceb2bde56d276673f86daaf"

