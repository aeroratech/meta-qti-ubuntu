inherit deb-dl

LICENSE = "GPL-3.0-with-openssl-exception & GFDL-1.2"

FULL_LINK = 'http://ports.ubuntu.com/ubuntu-ports/pool/main/w/wget/wget_1.20.3-1ubuntu1_arm64.deb'

DEB_NAME = 'wget_1.20.3-1ubuntu1_arm64.deb'

SRC_URI[md5sum] = "7feebd6c33e8d4e4331b024bfd0c10ee"

