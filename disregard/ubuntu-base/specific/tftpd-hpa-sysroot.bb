inherit deb-dl

LICENSE = "BSD-4-Clause & BSD-3-Clause"

FULL_LINK = 'http://ports.ubuntu.com/ubuntu-ports/pool/main/t/tftp-hpa/tftpd-hpa_5.2+20150808-1ubuntu4_arm64.deb'

DEB_NAME = 'tftpd-hpa_5.2+20150808-1ubuntu4_arm64.deb'

SRC_URI[md5sum] = "ebb9508a23d8d19803f81f3f3ac076b8"

