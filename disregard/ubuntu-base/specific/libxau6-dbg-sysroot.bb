inherit deb-dl

LICENSE = "MIT-open-group"

FULL_LINK = 'http://ports.ubuntu.com/ubuntu-ports/pool/main/libx/libxau/libxau6-dbg_1.0.9-0ubuntu1_arm64.deb'

DEB_NAME = 'libxau6-dbg_1.0.9-0ubuntu1_arm64.deb'

SRC_URI[md5sum] = "7e1a0007a7e9d80cd58b4cf6506cb05d"

