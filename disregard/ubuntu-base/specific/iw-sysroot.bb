inherit deb-dl

LICENSE = "ISC"

FULL_LINK = 'http://ports.ubuntu.com/ubuntu-ports/pool/main/i/iw/iw_5.4-1_arm64.deb'

DEB_NAME = 'iw_5.4-1_arm64.deb'

SRC_URI[md5sum] = "7acc4943334d9d7f24bf8a036d601571"

