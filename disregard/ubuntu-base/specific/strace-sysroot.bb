inherit deb-dl

LICENSE = "BSD-3-Clause"

FULL_LINK = 'http://ports.ubuntu.com/ubuntu-ports/pool/main/s/strace/strace_4.26-0.2ubuntu3_arm64.deb'

DEB_NAME = 'strace_4.26-0.2ubuntu3_arm64.deb'

SRC_URI[md5sum] = "95eeaaf9ed0a19754bfaeea23efe2b5d"

