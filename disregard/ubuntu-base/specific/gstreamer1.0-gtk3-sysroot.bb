inherit deb-dl

LICENSE = "LGPL-2.0+ & LGPL-2.1+ & MIT"

FULL_LINK = 'http://ports.ubuntu.com/ubuntu-ports/pool/main/g/gst-plugins-good1.0/gstreamer1.0-gtk3_1.16.2-1ubuntu2_arm64.deb'

DEB_NAME = 'gstreamer1.0-gtk3_1.16.2-1ubuntu2_arm64.deb'

SRC_URI[md5sum] = "0faee6e65363eea4a6417d554863686f"

