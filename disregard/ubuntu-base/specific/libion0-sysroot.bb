inherit deb-dl

LICENSE = "BSD-3-clause"

FULL_LINK = 'http://ports.ubuntu.com/ubuntu-ports/pool/universe/i/ion/libion0_3.2.1+dfsg-1.1_arm64.deb'

DEB_NAME = 'libion0_3.2.1+dfsg-1.1_arm64.deb'

SRC_URI[md5sum] = "8207a87f6dafca5990c8f77d73e39963"

