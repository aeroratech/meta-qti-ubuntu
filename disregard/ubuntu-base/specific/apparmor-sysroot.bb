inherit deb-dl

LICENSE = "GPL-2.0+"

FULL_LINK = 'http://ports.ubuntu.com/ubuntu-ports/pool/main/a/apparmor/apparmor_2.13.3-7ubuntu5_arm64.deb'

DEB_NAME = 'apparmor_2.13.3-7ubuntu5_arm64.deb'

SRC_URI[md5sum] = "bc7a56fa936fc7e91e876e7654302470"

