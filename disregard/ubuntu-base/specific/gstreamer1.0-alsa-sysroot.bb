inherit deb-dl

LICENSE = "LGPL-2.0+ & BSD-2-Clause & MIT"

FULL_LINK = 'http://ports.ubuntu.com/ubuntu-ports/pool/main/g/gst-plugins-base1.0/gstreamer1.0-alsa_1.16.2-4_arm64.deb'

DEB_NAME = 'gstreamer1.0-alsa_1.16.2-4_arm64.deb'

SRC_URI[md5sum] = "388e4821ee821da8432a7c341aa5e694"

