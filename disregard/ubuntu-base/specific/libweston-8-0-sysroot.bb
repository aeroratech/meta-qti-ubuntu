inherit deb-dl

LICENSE = "X11"

FULL_LINK = 'http://ports.ubuntu.com/ubuntu-ports/pool/universe/w/weston/libweston-8-0_8.0.0-1_arm64.deb'

DEB_NAME = 'libweston-8-0_8.0.0-1_arm64.deb'

SRC_URI[md5sum] = "56029ad5c44e5443f81db24eea3ee66e"

