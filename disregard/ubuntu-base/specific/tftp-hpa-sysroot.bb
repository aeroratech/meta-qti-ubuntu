inherit deb-dl

LICENSE = "BSD-4-Clause & BSD-3-Clause"

FULL_LINK = 'http://ports.ubuntu.com/ubuntu-ports/pool/main/t/tftp-hpa/tftp-hpa_5.2+20150808-1ubuntu4_arm64.deb'

DEB_NAME = 'tftp-hpa_5.2+20150808-1ubuntu4_arm64.deb'

SRC_URI[md5sum] = "0afac22a6ba783c1356db9309acc787c"

