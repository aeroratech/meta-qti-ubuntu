inherit deb-dl

LICENSE = "GPL-3.0-with-GCC-exception"

FULL_LINK = 'http://ports.ubuntu.com/ubuntu-ports/pool/main/g/gcc-10/libcc1-0_10-20200411-0ubuntu1_arm64.deb'

DEB_NAME = 'libcc1-0_10-20200411-0ubuntu1_arm64.deb'

SRC_URI[md5sum] = "e2aad0d94eb2f0c2d2ad9fe0d29c53ce"

