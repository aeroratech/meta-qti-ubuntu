inherit deb-dl

LICENSE = "LGPL-2.0+"

FULL_LINK = 'http://ports.ubuntu.com/ubuntu-ports/pool/main/g/gstreamer1.0/gir1.2-gstreamer-1.0_1.16.2-2_arm64.deb'

DEB_NAME = 'gir1.2-gstreamer-1.0_1.16.2-2_arm64.deb'

SRC_URI[md5sum] = "ade9a487816fca097685d7a9e894c281"

