inherit deb-dl

LICENSE = "GPL-3.0-with-GCC-exception"

FULL_LINK = 'http://ports.ubuntu.com/ubuntu-ports/pool/main/g/gcc-10/libgomp1_10-20200411-0ubuntu1_arm64.deb'

DEB_NAME = 'libgomp1_10-20200411-0ubuntu1_arm64.deb'

SRC_URI[md5sum] = "1c939fb1c4012378357fef2fbdf87b7c"

