inherit deb-dl

LICENSE = "MIT-Style"

FULL_LINK = 'http://ports.ubuntu.com/ubuntu-ports/pool/main/x/xkeyboard-config/xkb-data_2.29-2_all.deb'

DEB_NAME = 'xkb-data_2.29-2_all.deb'

SRC_URI[md5sum] = "4ec5c51b100981403888c7c3c08bfd5f"

