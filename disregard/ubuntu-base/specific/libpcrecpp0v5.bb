
LICENSE_libpcrecpp0v5 = "BSD-3-Clause"
SRC_URI += 'http://ports.ubuntu.com/ubuntu-portspool/main/p/pcre3/libpcrecpp0v5_8.39-12build1_arm64.deb;name=libpcrecpp0v5'
SRC_URI[libpcrecpp0v5.md5sum] = "cf50de20ce90a6a91221b9bdd3768ca0"

