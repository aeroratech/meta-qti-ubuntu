inherit deb-dl

LICENSE = "BSD-3-Clause"

FULL_LINK = 'http://ports.ubuntu.com/ubuntu-ports/pool/universe/w/wpa/hostapd_2.9-1ubuntu4_arm64.deb'

DEB_NAME = 'hostapd_2.9-1ubuntu4_arm64.deb'

SRC_URI[md5sum] = "ada7321b785fa7c9c237877ed2b27707"

