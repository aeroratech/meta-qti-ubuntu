
LICENSE_ssh-import-id = "GPL-3"
SRC_URI += 'http://ports.ubuntu.com/ubuntu-portspool/main/s/ssh-import-id/ssh-import-id_5.10-0ubuntu1_all.deb;name=ssh-import-id'
SRC_URI[ssh-import-id.md5sum] = "f97d1cf4ead43e10a650b0794c2bee8c"

