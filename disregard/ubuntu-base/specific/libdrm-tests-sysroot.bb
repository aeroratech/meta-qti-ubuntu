inherit deb-dl

LICENSE = "MIT"

FULL_LINK = 'http://ports.ubuntu.com/ubuntu-ports/pool/universe/libd/libdrm/libdrm-tests_2.4.101-2_arm64.deb'

DEB_NAME = 'libdrm-tests_2.4.101-2_arm64.deb'

SRC_URI[md5sum] = "32e769ae1730c5ba4c341237da092254"

