inherit deb-dl

LICENSE = "GPL-2.0 & LGPL-2.0 & BSD-3-Clause & MIT-Style"

FULL_LINK = 'http://ports.ubuntu.com/ubuntu-ports/pool/main/e/e2fsprogs/ss-dev_2.0-1.45.5-2ubuntu1_arm64.deb'

DEB_NAME = 'ss-dev_2.0-1.45.5-2ubuntu1_arm64.deb'

SRC_URI[md5sum] = "cca9d41ae25045754d16a53ee99afbd0"

