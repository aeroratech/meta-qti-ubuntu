inherit deb-dl

LICENSE = "GPL-2.0 | GPL-3.0"

FULL_LINK = 'http://ports.ubuntu.com/ubuntu-ports/pool/universe/d/dnsmasq/dnsmasq_2.80-1.1ubuntu1.4_all.deb'

DEB_NAME = 'dnsmasq_2.80-1.1ubuntu1.4_all.deb'

SRC_URI[md5sum] = "security.ubuntu.com"

