inherit deb-dl

LICENSE = "BSD-3-clause & BSD-2-clause & Powell-BSD-style & ISC & MIT & PD"

FULL_LINK = 'http://ports.ubuntu.com/ubuntu-ports/pool/main/o/openssh/openssh-server_8.2p1-4_arm64.deb'

DEB_NAME = 'openssh-server_8.2p1-4_arm64.deb'

SRC_URI[md5sum] = "c7417dec991c2d3713be16021308d6f6"

