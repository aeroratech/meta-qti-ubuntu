inherit deb-dl

LICENSE = "X11"

FULL_LINK = 'http://ports.ubuntu.com/ubuntu-ports/pool/universe/w/weston/weston_8.0.0-1_arm64.deb'

DEB_NAME = 'weston_8.0.0-1_arm64.deb'

SRC_URI[md5sum] = "5d605eaf74e79b6ca95cdd04f07192e6"

