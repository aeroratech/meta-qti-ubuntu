inherit deb-dl

LICENSE = "MIT-open-group"

FULL_LINK = 'http://ports.ubuntu.com/ubuntu-ports/pool/main/libx/libxdmcp/libxdmcp6-dbg_1.1.3-0ubuntu1_arm64.deb'

DEB_NAME = 'libxdmcp6-dbg_1.1.3-0ubuntu1_arm64.deb'

SRC_URI[md5sum] = "b0a4eadaf098a287e729ee400ea19eaa"

