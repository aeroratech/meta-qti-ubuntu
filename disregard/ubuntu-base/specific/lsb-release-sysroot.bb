inherit deb-dl

LICENSE = "GPL-2.0+"

FULL_LINK = 'http://ports.ubuntu.com/ubuntu-ports/pool/main/l/lsb/lsb-release_11.1.0ubuntu2_all.deb'

DEB_NAME = 'lsb-release_11.1.0ubuntu2_all.deb'

SRC_URI[md5sum] = "1150ded71500f4765a72add53e586636"

