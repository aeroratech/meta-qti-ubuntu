inherit deb-dl

LICENSE = "GPL-3.0+"

FULL_LINK = 'http://ports.ubuntu.com/ubuntu-ports/pool/main/g/gdb/gdb_9.1-0ubuntu1_arm64.deb'

DEB_NAME = 'gdb_9.1-0ubuntu1_arm64.deb'

SRC_URI[md5sum] = "ce80204f32ee5dc17cc637e7da39da1e"

