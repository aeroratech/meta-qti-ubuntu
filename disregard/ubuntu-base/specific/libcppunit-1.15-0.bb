
LICENSE_libcppunit-1.15-0 = "LGPL-2.1"
SRC_URI += 'http://ports.ubuntu.com/ubuntu-portspool/universe/c/cppunit/libcppunit-1.15-0_1.15.1-2build1_arm64.deb;name=libcppunit-1.15-0'
SRC_URI[libcppunit-1.15-0.md5sum] = "fab4468b2a571446a8b0e4fab8bdaca6"

