inherit deb-dl

LICENSE = "PSF-2.0 & MIT"

FULL_LINK = 'http://ports.ubuntu.com/ubuntu-ports/pool/universe/p/python-defaults/python2-dbg_2.7.17-2ubuntu4_arm64.deb'

DEB_NAME = 'python2-dbg_2.7.17-2ubuntu4_arm64.deb'

SRC_URI[md5sum] = "09c4de1f301471a28e111f0a98f4a6ed"

