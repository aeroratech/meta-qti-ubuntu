inherit deb-dl

LICENSE = "LGPL-2.0+ & BSD & MIT"

FULL_LINK = 'http://ports.ubuntu.com/ubuntu-ports/pool/main/g/gst-plugins-base1.0/gstreamer1.0-plugins-base-dbg_1.16.2-4_arm64.deb'

DEB_NAME = 'gstreamer1.0-plugins-base-dbg_1.16.2-4_arm64.deb'

SRC_URI[md5sum] = "cc7e51d11ee5f55b9ebae2cbcb0dece8"

