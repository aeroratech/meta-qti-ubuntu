inherit deb-dl

LICENSE = "BSD-3-Clause & MIT"

FULL_LINK = 'http://ports.ubuntu.com/ubuntu-ports/pool/main/g/gcc-10/libtsan0_10-20200411-0ubuntu1_arm64.deb'

DEB_NAME = 'libtsan0_10-20200411-0ubuntu1_arm64.deb'

SRC_URI[md5sum] = "99f3619b3bff228ce3a05b9647cb1cae"

