inherit deb-dl

LICENSE = "PSF-2.0 & MIT"

FULL_LINK = 'http://ports.ubuntu.com/ubuntu-ports/pool/main/p/python3-defaults/python3-dbg_3.8.2-0ubuntu2_arm64.deb'

DEB_NAME = 'python3-dbg_3.8.2-0ubuntu2_arm64.deb'

SRC_URI[md5sum] = "1cf5301a88fc433a72163b77b752638b"

