inherit deb-dl

LICENSE = "BSD-2-Clause"

FULL_LINK = 'http://ports.ubuntu.com/ubuntu-ports/pool/universe/d/dhcpcd5/dhcpcd5_7.1.0-2build1_arm64.deb'

DEB_NAME = 'dhcpcd5_7.1.0-2build1_arm64.deb'

SRC_URI[md5sum] = "5ce6625f780c7dbc2360fc0634c14d55"

