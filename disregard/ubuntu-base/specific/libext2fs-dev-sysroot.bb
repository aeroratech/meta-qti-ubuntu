inherit deb-dl

LICENSE = "GPL-2.0 & LGPL-2.0 & BSD-3-Clause & MIT"

FULL_LINK = 'http://ports.ubuntu.com/ubuntu-ports/pool/main/e/e2fsprogs/libext2fs-dev_1.45.5-2ubuntu1_arm64.deb'

DEB_NAME = 'libext2fs-dev_1.45.5-2ubuntu1_arm64.deb'

SRC_URI[md5sum] = "94593daa14863e87d01d75903e8d3f9e"

