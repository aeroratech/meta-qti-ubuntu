inherit deb-dl

LICENSE = "GPL-3.0+"

FULL_LINK = 'http://ports.ubuntu.com/ubuntu-ports/pool/universe/g/gnupg2/gnupg2_2.2.19-3ubuntu2_all.deb'

DEB_NAME = 'gnupg2_2.2.19-3ubuntu2_all.deb'

SRC_URI[md5sum] = "e51e9b8954f66158df23fe2b1281facf"

