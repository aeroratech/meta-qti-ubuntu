inherit deb-dl

LICENSE = "Apache-2.0"

FULL_LINK = 'http://ports.ubuntu.com/ubuntu-ports/pool/universe/p/python-argcomplete/python3-argcomplete_1.8.1-1.3ubuntu1_all.deb'

DEB_NAME = 'python3-argcomplete_1.8.1-1.3ubuntu1_all.deb'

SRC_URI[md5sum] = "3306b4b7eb80f1391b43841dd20b6cd2"

