inherit deb-dl

LICENSE = "GPL-3.0-with-GCC-exception"

FULL_LINK = 'http://ports.ubuntu.com/ubuntu-ports/pool/main/g/gcc-10/libitm1_10-20200411-0ubuntu1_arm64.deb'

DEB_NAME = 'libitm1_10-20200411-0ubuntu1_arm64.deb'

SRC_URI[md5sum] = "6963b652e98720ff97e27981c6fd164b"

