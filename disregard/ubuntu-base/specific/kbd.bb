
LICENSE_kbd = "GPL-2+"
SRC_URI += 'http://ports.ubuntu.com/ubuntu-portspool/main/k/kbd/kbd_2.0.4-4ubuntu2_arm64.deb;name=kbd'
SRC_URI[kbd.md5sum] = "465b328d79d56d1486799836fc40f5ab"

