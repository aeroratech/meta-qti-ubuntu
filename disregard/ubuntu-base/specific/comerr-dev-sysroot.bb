inherit deb-dl

LICENSE = "GPL-2.0 & LGPL-2.0 & MIT-style & BSD-3-Clause"

FULL_LINK = 'http://ports.ubuntu.com/ubuntu-ports/pool/main/e/e2fsprogs/comerr-dev_2.1-1.45.5-2ubuntu1_arm64.deb'

DEB_NAME = 'comerr-dev_2.1-1.45.5-2ubuntu1_arm64.deb'

SRC_URI[md5sum] = "07d13943b9d24eae6a63f18cd55fc7ca"

