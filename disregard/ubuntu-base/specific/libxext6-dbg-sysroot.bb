inherit deb-dl

LICENSE = "MIT-style"

FULL_LINK = 'http://ports.ubuntu.com/ubuntu-ports/pool/main/libx/libxext/libxext6-dbg_1.3.4-0ubuntu1_arm64.deb'

DEB_NAME = 'libxext6-dbg_1.3.4-0ubuntu1_arm64.deb'

SRC_URI[md5sum] = "e581eb284f6ba3dccbc8d933dd7698d5"

