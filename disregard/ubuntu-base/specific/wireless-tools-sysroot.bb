inherit deb-dl

LICENSE = "GPL-2.0+ & LGPL-2.1+"

FULL_LINK = 'http://ports.ubuntu.com/ubuntu-ports/pool/main/w/wireless-tools/wireless-tools_30~pre9-13ubuntu1_arm64.deb'

DEB_NAME = 'wireless-tools_30~pre9-13ubuntu1_arm64.deb'

SRC_URI[md5sum] = "33650c37d1f21218a7f3686d04cb8171"

