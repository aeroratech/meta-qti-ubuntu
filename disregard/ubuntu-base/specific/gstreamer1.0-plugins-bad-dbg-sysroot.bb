inherit deb-dl

LICENSE = "LGPL-2.0+ & MIT & GPL-2.0+ & GPL-3.0+ & BSD & MPL-1.1"

FULL_LINK = 'http://ports.ubuntu.com/ubuntu-ports/pool/universe/g/gst-plugins-bad1.0/gstreamer1.0-plugins-bad-dbg_1.16.2-2.1ubuntu1_arm64.deb'

DEB_NAME = 'gstreamer1.0-plugins-bad-dbg_1.16.2-2.1ubuntu1_arm64.deb'

SRC_URI[md5sum] = "5d9433ccaa2c8a743875ce6ec24a14eb"

