inherit deb-dl

LICENSE = "GPL-2.0+"

FULL_LINK = 'http://ports.ubuntu.com/ubuntu-ports/pool/main/n/net-tools/net-tools_1.60+git20180626.aebd88e-1ubuntu1_arm64.deb'

DEB_NAME = 'net-tools_1.60+git20180626.aebd88e-1ubuntu1_arm64.deb'

SRC_URI[md5sum] = "40c81ba93bd5b1c7e4e5346e4598af45"

