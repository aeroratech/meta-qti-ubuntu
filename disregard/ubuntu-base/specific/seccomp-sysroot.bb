inherit deb-dl

LICENSE = "LGPL-2.1"

FULL_LINK = 'http://ports.ubuntu.com/ubuntu-ports/pool/main/libs/libseccomp/seccomp_2.4.3-1ubuntu1_arm64.deb'

DEB_NAME = 'seccomp_2.4.3-1ubuntu1_arm64.deb'

SRC_URI[md5sum] = "6e5e06dfec7d144d013649c5f64379d5"

