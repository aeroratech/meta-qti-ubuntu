inherit deb-dl

LICENSE = "LGPL-2.1"

FULL_LINK = 'http://ports.ubuntu.com/ubuntu-ports/pool/main/libs/libseccomp/libseccomp2_2.4.3-1ubuntu1_arm64.deb'

DEB_NAME = 'libseccomp2_2.4.3-1ubuntu1_arm64.deb'

SRC_URI[md5sum] = "6d0526444c271a2b2a3647e45bcf8677"

