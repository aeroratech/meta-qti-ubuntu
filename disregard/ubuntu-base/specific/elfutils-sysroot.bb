inherit deb-dl

LICENSE = "GPL-3.0+ | GPL-2.0+"

FULL_LINK = 'http://ports.ubuntu.com/ubuntu-ports/pool/main/e/elfutils/elfutils_0.176-1.1build1_arm64.deb'

DEB_NAME = 'elfutils_0.176-1.1build1_arm64.deb'

SRC_URI[md5sum] = "6282b3f694cf7b61ddb63a292f771963"

