inherit deb-dl

LICENSE = "GPL-2.0+"

FULL_LINK = 'http://ports.ubuntu.com/ubuntu-ports/pool/main/u/usbutils/usbutils_012-2_arm64.deb'

DEB_NAME = 'usbutils_012-2_arm64.deb'

SRC_URI[md5sum] = "c265ed6d47682826efc5461d29cb583d"

