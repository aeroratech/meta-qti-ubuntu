LICENSE = "MIT"

FULL_LINK = 'http://ports.ubuntu.com/ubuntu-ports/pool/main/libx/libxau/libxau6-dbg_1.0.8-1_arm64.deb'
DEB_NAME = 'libxau6-dbg_1.0.8-1_arm64.deb'

SRC_URI[md5sum] = "c146c8ba2f63e2f16b38f1d5b76bfdaf"
