
LICENSE = "MIT"

FULL_LINK = 'http://ports.ubuntu.com/ubuntu-ports/pool/universe/w/weston/weston_3.0.0-1_arm64.deb'
DEB_NAME = 'weston_3.0.0-1_arm64.deb'

SRC_URI[md5sum] = "22cfeb82d9c5da9a7c552501a905f433"
