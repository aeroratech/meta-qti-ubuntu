
LICENSE = "LGPL-2.1+ & GPL-2.0"

FULL_LINK = 'http://ports.ubuntu.com/ubuntu-ports/pool/universe/p/pulseaudio/pulseaudio-esound-compat_11.1-1ubuntu7_arm64.deb'
DEB_NAME = 'pulseaudio-esound-compat_11.1-1ubuntu7_arm64.deb'

SRC_URI[md5sum] = "c56db50b890e3448ba4b84ce753d96c9"
