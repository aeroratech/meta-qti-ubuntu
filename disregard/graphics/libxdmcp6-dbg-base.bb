LICENSE = "MIT"

FULL_LINK = 'http://ports.ubuntu.com/ubuntu-ports/pool/main/libx/libxdmcp/libxdmcp6-dbg_1.1.2-3_arm64.deb'
DEB_NAME = 'libxdmcp6-dbg_1.1.2-3_arm64.deb'

SRC_URI[md5sum] = "6df15f64bdc60aa68101bdf2a1da69a3"
