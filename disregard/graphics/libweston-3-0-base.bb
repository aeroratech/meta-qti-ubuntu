
LICENSE = "MIT"

FULL_LINK = 'http://ports.ubuntu.com/ubuntu-ports/pool/universe/w/weston/libweston-3-0_3.0.0-1_arm64.deb'
DEB_NAME = 'libweston-3-0_3.0.0-1_arm64.deb'

SRC_URI[md5sum] = "71b7c2e7cb85c109c3dcdd4deeaf249a"
