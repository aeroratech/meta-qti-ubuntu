
LICENSE = "MIT"

FULL_LINK = 'http://ports.ubuntu.com/ubuntu-ports/pool/main/m/mesa/openssl/libgbm-dev_18.0.0~rc5-1ubuntu1_arm64.deb'
DEB_NAME = 'libgbm-dev_18.0.0~rc5-1ubuntu1_arm64.deb'

SRC_URI[md5sum] = "4380b2e5e217fa090ab256d690d13753"
