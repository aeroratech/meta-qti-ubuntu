LICENSE = "MIT"

FULL_LINK = 'http://ports.ubuntu.com/ubuntu-ports/pool/main/libx/libxext/libxext6-dbg_1.3.3-1_arm64.deb'
DEB_NAME = 'libxext6-dbg_1.3.3-1_arm64.deb'

SRC_URI[md5sum] = "696cc4c7cea5d3a437e7534f913a193d"
