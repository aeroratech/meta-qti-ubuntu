
LICENSE = "LGPL-2.0+ & LGPL-2.1+"

FULL_LINK = 'http://ports.ubuntu.com/ubuntu-ports/pool/universe/g/gst-libav1.0/gstreamer1.0-libav_1.14.0-1_arm64.deb'
DEB_NAME = 'gstreamer1.0-libav_1.14.0-1_arm64.deb'

SRC_URI[md5sum] = "aa22c7216079fb4420b35ce4a9c7c5e8"
