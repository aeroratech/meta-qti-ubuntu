LICENSE = "MIT-style"

FULL_LINK = 'http://ports.ubuntu.com/ubuntu-ports/pool/main/libs/libsm/libsm6-dbg_1.2.2-1_arm64.deb'
DEB_NAME = 'libsm6-dbg_1.2.2-1_arm64.deb'

SRC_URI[md5sum] = "cc980fd62515f7fa4caa873dbeaa1e13"
