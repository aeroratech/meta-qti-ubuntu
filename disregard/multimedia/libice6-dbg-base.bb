LICENSE = "MIT-style"

FULL_LINK = 'http://ports.ubuntu.com/ubuntu-ports/pool/main/libi/libice/libice6-dbg_1.0.9-2_arm64.deb'
DEB_NAME = 'libice6-dbg_1.0.9-2_arm64.deb'

SRC_URI[md5sum] = "f3efc40596acf7e23aead3459bb4d18a"
