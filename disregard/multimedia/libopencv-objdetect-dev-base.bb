
LICENSE = "BSD-3-clause"

FULL_LINK = 'http://ports.ubuntu.com/ubuntu-ports/pool/universe/o/opencv/libopencv-objdetect-dev_3.2.0+dfsg-4build2_arm64.deb'
DEB_NAME = 'libopencv-objdetect-dev_3.2.0+dfsg-4build2_arm64.deb'

SRC_URI[md5sum] = "f0bc85e6b116cc7645fc45effddf96f1"
