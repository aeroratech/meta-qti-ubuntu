
LICENSE = "GPL-2.0+ & LGPL-2.0+"

FULL_LINK = 'http://ports.ubuntu.com/ubuntu-ports/pool/main/g/gst-plugins-base1.0/gstreamer1.0-plugins-base-apps_1.14.0-2ubuntu1_arm64.deb'
DEB_NAME = 'gstreamer1.0-plugins-base-apps_1.14.0-2ubuntu1_arm64.deb'

SRC_URI[md5sum] = "99b74fe958a55defaa056d812143cb33"
