LICENSE = "PSF-2.0"

FULL_LINK = 'http://ports.ubuntu.com/ubuntu-ports/pool/main/p/python3-defaults/python3-dbg_3.6.5-3_arm64.deb'
DEB_NAME = 'python3-dbg_3.6.5-3_arm64.deb'

SRC_URI[md5sum] = "38eb2e8272736f894e99e39f7413f65e"
