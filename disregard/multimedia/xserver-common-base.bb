LICENSE = "MIT-X"

FULL_LINK = 'http://ports.ubuntu.com/ubuntu-ports/pool/main/x/xorg-server/xserver-common_1.19.6-1ubuntu4.6_all.deb'
DEB_NAME = 'xserver-common_1.19.6-1ubuntu4.6_all.deb'

SRC_URI[md5sum] = "4ca6304fccafacc5f7d77abc8a813488"
