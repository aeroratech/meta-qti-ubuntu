
LICENSE = "Khronos & GPL-3.0+"

FULL_LINK = 'http://ports.ubuntu.com/ubuntu-ports/pool/main/k/khronos-opencl-headers/opencl-c-headers_2.2~2018.02.21-gb5c3680-1_all.deb'
DEB_NAME = 'opencl-c-headers_2.2~2018.02.21-gb5c3680-1_all.deb'

SRC_URI[md5sum] = "57c7efd8f1bdda9c868e26cccf70c625"
