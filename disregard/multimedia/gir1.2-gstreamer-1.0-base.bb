
LICENSE = "GPL-2.0+ & LGPL-2.0+"

FULL_LINK = 'http://ports.ubuntu.com/ubuntu-ports/pool/main/g/gstreamer1.0/gir1.2-gstreamer-1.0_1.14.0-1_arm64.deb'
DEB_NAME = 'gir1.2-gstreamer-1.0_1.14.0-1_arm64.deb'

SRC_URI[md5sum] = "e9b444d68d261afe62073ab82da36f49"
