
LICENSE = "BSD-3-clause"

FULL_LINK = 'http://ports.ubuntu.com/ubuntu-ports/pool/universe/o/opencv/libopencv-viz-dev_3.2.0+dfsg-4build2_arm64.deb'
DEB_NAME = 'libopencv-viz-dev_3.2.0+dfsg-4build2_arm64.deb'

SRC_URI[md5sum] = "634604e6491ff594eedc4d0f60ae33d2"
