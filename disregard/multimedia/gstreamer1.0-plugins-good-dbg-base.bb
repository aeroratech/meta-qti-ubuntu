
LICENSE = "GPL-2.0+ & LGPL-2.0+"

FULL_LINK = 'http://ports.ubuntu.com/ubuntu-ports/pool/universe/g/gst-plugins-good1.0/gstreamer1.0-plugins-good-dbg_1.14.0-1ubuntu1_arm64.deb'
DEB_NAME = 'gstreamer1.0-plugins-good-dbg_1.14.0-1ubuntu1_arm64.deb'

SRC_URI[md5sum] = "1f2c453bf3fde0dbecf36e3bf7093d87"
