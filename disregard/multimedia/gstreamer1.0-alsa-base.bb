
LICENSE = "GPL-2.0+ & LGPL-2.0+"

FULL_LINK = 'http://ports.ubuntu.com/ubuntu-ports/pool/main/g/gst-plugins-base1.0/gstreamer1.0-alsa_1.14.0-2ubuntu1_arm64.deb'
DEB_NAME = 'gstreamer1.0-alsa_1.14.0-2ubuntu1_arm64.deb'

SRC_URI[md5sum] = "9c53094c6168bf7c2a095a007c1a8e12"
