
LICENSE = "GPL-2.0+ & LGPL-2.0+"

FULL_LINK = 'http://ports.ubuntu.com/ubuntu-ports/pool/main/g/gstreamer1.0/gstreamer1.0-tools_1.14.0-1_arm64.deb'
DEB_NAME = 'gstreamer1.0-tools_1.14.0-1_arm64.deb'

SRC_URI[md5sum] = "8b75fadfbb327027374018346d34e171"
