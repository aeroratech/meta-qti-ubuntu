
LICENSE = "MIT & SGI-B-2.0 & BSD & Apache-2.0 & BSL-1.0"

FULL_LINK = 'http://ports.ubuntu.com/ubuntu-ports/pool/main/m/mesa/mesa-common-dev_18.0.0~rc5-1ubuntu1_arm64.deb'
DEB_NAME = 'mesa-common-dev_18.0.0~rc5-1ubuntu1_arm64.deb'

SRC_URI[md5sum] = "28b80eb0ee72efbefaaaeeffce67226a"
