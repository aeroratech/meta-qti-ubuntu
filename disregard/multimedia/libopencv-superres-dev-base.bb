
LICENSE = "BSD-3-clause"

FULL_LINK = 'http://ports.ubuntu.com/ubuntu-ports/pool/universe/o/opencv/libopencv-superres-dev_3.2.0+dfsg-4build2_arm64.deb'
DEB_NAME = 'libopencv-superres-dev_3.2.0+dfsg-4build2_arm64.deb'

SRC_URI[md5sum] = "e8a10d946a708156b09cab0131b8a448"
