
LICENSE = "GPL-3.0-with-GCC-exception & GPLv3"

FULL_LINK = 'http://ports.ubuntu.com/ubuntu-ports/pool/main/g/gcc-8/libcc1-0_8-20180414-1ubuntu2_arm64.deb'
DEB_NAME = 'libcc1-0_8-20180414-1ubuntu2_arm64.deb'

SRC_URI[md5sum] = "52783789b0dcff48cd80807098b41541"
