LICENSE = "MIT-style"

FULL_LINK = 'http://ports.ubuntu.com/ubuntu-ports/pool/main/libx/libxkbfile/libxkbfile1-dbg_1.0.9-2_arm64.deb'
DEB_NAME = 'libxkbfile1-dbg_1.0.9-2_arm64.deb'

SRC_URI[md5sum] = "7ce5fa94ba04d1ecaf6c8fd3763d4c20"
