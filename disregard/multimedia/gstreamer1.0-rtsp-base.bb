
LICENSE = "LGPL-2.0+"

FULL_LINK = 'http://ports.ubuntu.com/ubuntu-ports/pool/universe/g/gst-rtsp-server1.0/gstreamer1.0-rtsp_1.14.0-1_arm64.deb'
DEB_NAME = 'gstreamer1.0-rtsp_1.14.0-1_arm64.deb'

SRC_URI[md5sum] = "9062877ad14da4b583b3cbf3026d1450"
