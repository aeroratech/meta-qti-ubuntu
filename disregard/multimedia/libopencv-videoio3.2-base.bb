
LICENSE = "BSD-3-clause"

FULL_LINK = 'http://ports.ubuntu.com/ubuntu-ports/pool/universe/o/opencv/libopencv-videoio3.2_3.2.0+dfsg-4build2_arm64.deb'
DEB_NAME = 'libopencv-videoio3.2_3.2.0+dfsg-4build2_arm64.deb'

SRC_URI[md5sum] = "82c4ebbba541eb163c3e7d3656865afe"
