
LICENSE = "BSD-3-clause"

FULL_LINK = 'http://ports.ubuntu.com/ubuntu-ports/pool/universe/o/opencv/libopencv-ts-dev_3.2.0+dfsg-4build2_arm64.deb'
DEB_NAME = 'libopencv-ts-dev_3.2.0+dfsg-4build2_arm64.deb'

SRC_URI[md5sum] = "cb64e99df3dd091d867a982b00efa060"
