
LICENSE = "PD & GPL-2.0+"

FULL_LINK = 'http://ports.ubuntu.com/ubuntu-ports/pool/main/s/sqlite3/libsqlite3-dev_3.22.0-1_arm64.deb'
DEB_NAME = 'libsqlite3-dev_3.22.0-1_arm64.deb'

SRC_URI[md5sum] = "ab99d26ac1f4437cb815e469b9de98ca"
