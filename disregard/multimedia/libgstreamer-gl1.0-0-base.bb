
LICENSE = "GPL-2.0+ & LGPL-2.0+"

FULL_LINK = 'http://ports.ubuntu.com/ubuntu-ports/pool/main/g/gst-plugins-base1.0/libgstreamer-gl1.0-0_1.14.0-2ubuntu1_arm64.deb'
DEB_NAME = 'libgstreamer-gl1.0-0_1.14.0-2ubuntu1_arm64.deb'

SRC_URI[md5sum] = "fe514e1db796a58df220d3d35ded8d93"
