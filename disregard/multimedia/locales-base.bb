
LICENSE = "LGPL-2.1+ & GPL-2.0+"

FULL_LINK = 'http://ports.ubuntu.com/ubuntu-ports/pool/main/g/glibc/locales_2.27-3ubuntu1_all.deb'
DEB_NAME = 'locales_2.27-3ubuntu1_all.deb'

SRC_URI[md5sum] = "f3611a13553e954aa81b368d44f7e3f9"
