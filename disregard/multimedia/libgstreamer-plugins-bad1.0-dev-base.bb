
LICENSE = "GPL-2.0+ & LGPL-2.0+ & LGPL-2.1+"

FULL_LINK = 'http://ports.ubuntu.com/ubuntu-ports/pool/universe/g/gst-plugins-bad1.0/libgstreamer-plugins-bad1.0-dev_1.14.0-1ubuntu1_arm64.deb'
DEB_NAME = 'libgstreamer-plugins-bad1.0-dev_1.14.0-1ubuntu1_arm64.deb'

SRC_URI[md5sum] = "6458d55f719ab82248df0cc86397c6f6"
