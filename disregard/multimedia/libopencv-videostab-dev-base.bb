
LICENSE = "BSD-3-clause"

FULL_LINK = 'http://ports.ubuntu.com/ubuntu-ports/pool/universe/o/opencv/libopencv-videostab-dev_3.2.0+dfsg-4build2_arm64.deb'
DEB_NAME = 'libopencv-videostab-dev_3.2.0+dfsg-4build2_arm64.deb'

SRC_URI[md5sum] = "c6fa12ac06225890eaff7ee5e477f5a0"
