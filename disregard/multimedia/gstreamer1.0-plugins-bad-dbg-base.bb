
LICENSE = "GPL-2.0+ & LGPL-2.0+ & LGPL-2.1+"

FULL_LINK = 'http://ports.ubuntu.com/ubuntu-ports/pool/universe/g/gst-plugins-bad1.0/gstreamer1.0-plugins-bad-dbg_1.14.0-1ubuntu1_arm64.deb'
DEB_NAME = 'gstreamer1.0-plugins-bad-dbg_1.14.0-1ubuntu1_arm64.deb'

SRC_URI[md5sum] = "4ffdfffb6dcc5ac71b7a4e2d11c508cf"
