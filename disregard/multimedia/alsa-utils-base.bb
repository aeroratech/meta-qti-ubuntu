
LICENSE = "LPGL-2.1+"

FULL_LINK = 'http://ports.ubuntu.com/ubuntu-ports/pool/main/a/alsa-utils/alsa-utils_1.1.3-1ubuntu1_arm64.deb'
DEB_NAME = 'alsa-utils_1.1.3-1ubuntu1_arm64.deb'

SRC_URI[md5sum] = "7f47ee7c8b018b5f74f1b24da6f5f4ec"
