LICENSE = "MIT-X"

FULL_LINK = 'http://ports.ubuntu.com/ubuntu-ports/pool/main/x/xorg-server/xserver-xorg-core_1.19.6-1ubuntu4_arm64.deb'
DEB_NAME = 'xserver-xorg-core_1.19.6-1ubuntu4_arm64.deb'

SRC_URI[md5sum] = "6ba53799945a1611030d57842a95329f"
