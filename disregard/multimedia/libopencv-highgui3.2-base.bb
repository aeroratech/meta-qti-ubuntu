
LICENSE = "BSD-3-clause"

FULL_LINK = 'http://ports.ubuntu.com/ubuntu-ports/pool/universe/o/opencv/libopencv-highgui3.2_3.2.0+dfsg-4build2_arm64.deb'
DEB_NAME = 'libopencv-highgui3.2_3.2.0+dfsg-4build2_arm64.deb'

SRC_URI[md5sum] = "7968559465067b17ca582c882218cadf"
