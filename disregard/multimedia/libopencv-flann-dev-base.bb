
LICENSE = "BSD-3-clause"

FULL_LINK = 'http://ports.ubuntu.com/ubuntu-ports/pool/universe/o/opencv/libopencv-flann-dev_3.2.0+dfsg-4build2_arm64.deb'
DEB_NAME = 'libopencv-flann-dev_3.2.0+dfsg-4build2_arm64.deb'

SRC_URI[md5sum] = "9f1668056155bb3b3d0c0ac51be1e233"
