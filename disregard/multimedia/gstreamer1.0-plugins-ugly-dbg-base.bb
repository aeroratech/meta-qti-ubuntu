
LICENSE = "GPL-2.0+ & LGPL-2.1+ & LGPL-2.0+"

FULL_LINK = 'http://ports.ubuntu.com/ubuntu-ports/pool/universe/g/gst-plugins-ugly1.0/gstreamer1.0-plugins-ugly-dbg_1.14.0-1_arm64.deb'
DEB_NAME = 'gstreamer1.0-plugins-ugly-dbg_1.14.0-1_arm64.deb'

SRC_URI[md5sum] = "0059a07bb7b0147a7e0c1ec08ed2dcca"
