LICENSE = "PSF-2.0"

FULL_LINK = 'http://ports.ubuntu.com/ubuntu-ports/pool/main/p/python-defaults/python-dbg_2.7.15~rc1-1_arm64.deb'
DEB_NAME = 'python-dbg_2.7.15~rc1-1_arm64.deb'

SRC_URI[md5sum] = "9d764591393a286028a830b8ae13b7f2"
