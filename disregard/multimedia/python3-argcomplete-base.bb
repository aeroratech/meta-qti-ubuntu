
LICENSE = "Apache-2.0"

FULL_LINK = 'http://ports.ubuntu.com/ubuntu-ports/pool/universe/p/python-argcomplete/python3-argcomplete_1.8.1-1ubuntu1_all.deb'
DEB_NAME = 'python3-argcomplete_1.8.1-1ubuntu1_all.deb'

SRC_URI[md5sum] = "87cb3cf2cb41c5d3dd5a72635b252a53"
