
LICENSE = "BSD-3-clause"

FULL_LINK = 'http://ports.ubuntu.com/ubuntu-ports/pool/universe/o/opencv/libopencv-ml-dev_3.2.0+dfsg-4build2_arm64.deb'
DEB_NAME = 'libopencv-ml-dev_3.2.0+dfsg-4build2_arm64.deb'

SRC_URI[md5sum] = "d94fabc5bb0160c71604fd9620284f36"
