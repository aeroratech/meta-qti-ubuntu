
LICENSE = "MIT & SGI-B-2.0 & BSD & Apache-2.0 & BSL-1.0"

FULL_LINK = 'http://ports.ubuntu.com/ubuntu-ports/pool/main/m/mesa/libgles2-mesa-dev_18.0.0~rc5-1ubuntu1_arm64.deb'
DEB_NAME = 'libgles2-mesa-dev_18.0.0~rc5-1ubuntu1_arm64.deb'

SRC_URI[md5sum] = "1ad33b8814d4626671fb2ac5c3c30c9d"
