
LICENSE = "GPL-2.0 & BSD-3-Clause"

FULL_LINK = 'http://ports.ubuntu.com/ubuntu-ports/pool/main/l/lsb/lsb-release_9.20170808ubuntu1_all.deb'
DEB_NAME = 'lsb-release_9.20170808ubuntu1_all.deb'

SRC_URI[md5sum] = "728dc607f528c05c02e25c7a13db5aea"
