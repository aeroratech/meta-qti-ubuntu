
LICENSE = "BSD-3-Clause"

FULL_LINK = 'http://ports.ubuntu.com/ubuntu-ports/pool/universe/o/opencv/libopencv-contrib3.2_3.2.0+dfsg-4build2_arm64.deb'
DEB_NAME = 'libopencv-contrib3.2_3.2.0+dfsg-4build2_arm64.deb'

SRC_URI[md5sum] = "ae344d9b903d80e5ef4f53a159fee2a9"
