LICENSE = "MIT"

FULL_LINK = 'http://ports.ubuntu.com/ubuntu-ports/pool/main/libf/libfontenc/libfontenc1-dbg_1.1.3-1_arm64.deb'
DEB_NAME = 'libfontenc1-dbg_1.1.3-1_arm64.deb'

SRC_URI[md5sum] = "8e8526607865a2f34d6cc3aa53c175a2"
