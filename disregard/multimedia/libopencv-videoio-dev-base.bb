
LICENSE = "BSD-3-clause"

FULL_LINK = 'http://ports.ubuntu.com/ubuntu-ports/pool/universe/o/opencv/libopencv-videoio-dev_3.2.0+dfsg-4build2_arm64.deb'
DEB_NAME = 'libopencv-videoio-dev_3.2.0+dfsg-4build2_arm64.deb'

SRC_URI[md5sum] = "fda52b289f62f0260bebd09de07b85c4"
