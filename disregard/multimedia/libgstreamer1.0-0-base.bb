
LICENSE = "GPL-2.0+ & LGPL-2.0+"

FULL_LINK = 'http://ports.ubuntu.com/ubuntu-ports/pool/main/g/gstreamer1.0/libgstreamer1.0-0_1.14.0-1_arm64.deb'
DEB_NAME = 'libgstreamer1.0-0_1.14.0-1_arm64.deb'

SRC_URI[md5sum] = "11acc169bc023cc788abcc244d13e003"
