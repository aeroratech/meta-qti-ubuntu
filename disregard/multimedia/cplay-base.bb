
LICENSE = "GPL-2.0+"

FULL_LINK = 'http://ports.ubuntu.com/ubuntu-ports/pool/universe/c/cplay/cplay_1.50-1_all.deb'
DEB_NAME = 'cplay_1.50-1_all.deb'

SRC_URI[md5sum] = "c09dc6a5482b124bb2e7a3ef65146d6a"
