LICENSE = "MIT-style"

FULL_LINK = 'http://ports.ubuntu.com/ubuntu-ports/pool/main/libx/libxxf86vm/libxxf86vm1-dbg_1.1.4-1_arm64.deb'
DEB_NAME = 'libxxf86vm1-dbg_1.1.4-1_arm64.deb'

SRC_URI[md5sum] = "78fb94f9a2600073d34a405ac09e9d6e"
