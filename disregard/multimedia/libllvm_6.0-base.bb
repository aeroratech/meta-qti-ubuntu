LICENSE = "GPL-2.0+"

FULL_LINK = 'http://ports.ubuntu.com/ubuntu-ports/pool/universe/l/llvm-defaults/llvm_6.0-41~exp4_arm64.deb'
DEB_NAME = 'llvm_6.0-41~exp4_arm64.deb'

SRC_URI[md5sum] = "09bacfb4aaf782e59e3ebd7076fa26ca"
