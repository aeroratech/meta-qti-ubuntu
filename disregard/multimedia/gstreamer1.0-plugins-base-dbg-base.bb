
LICENSE = "GPL-2.0+ & LGPL-2.0+"

FULL_LINK = 'http://ports.ubuntu.com/ubuntu-ports/pool/main/g/gst-plugins-base1.0/gstreamer1.0-plugins-base-dbg_1.14.0-2ubuntu1_arm64.deb'
DEB_NAME = 'gstreamer1.0-plugins-base-dbg_1.14.0-2ubuntu1_arm64.deb'

SRC_URI[md5sum] = "dff076d2ed0381065e64ee557428389f"
