
LICENSE = "BSD-3-clause"

FULL_LINK = 'http://ports.ubuntu.com/ubuntu-ports/pool/universe/o/opencv/libopencv-features2d3.2_3.2.0+dfsg-4build2_arm64.deb'
DEB_NAME = 'libopencv-features2d3.2_3.2.0+dfsg-4build2_arm64.deb'

SRC_URI[md5sum] = "742d7312f1f8f3baf1d7fa4cbc656af4"
