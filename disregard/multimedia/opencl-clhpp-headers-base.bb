
LICENSE = "Khronos & MIT"

FULL_LINK = 'http://ports.ubuntu.com/ubuntu-ports/pool/universe/k/khronos-opencl-clhpp/opencl-clhpp-headers_2.0.10+git12-g5dd8bb9-1_all.deb'
DEB_NAME = 'opencl-clhpp-headers_2.0.10+git12-g5dd8bb9-1_all.deb'

SRC_URI[md5sum] = "71afcae8a4278b6e08bf690cc085f0c5"
