
LICENSE = "BSD-3-clause"

FULL_LINK = 'http://ports.ubuntu.com/ubuntu-ports/pool/universe/o/opencv/libopencv3.2-java_3.2.0+dfsg-4ubuntu0.1_all.deb'
DEB_NAME = 'libopencv3.2-java_3.2.0+dfsg-4ubuntu0.1_all.deb'

SRC_URI[md5sum] = "752ec6df60749acad72b394fde63973c"
