
LICENSE = "BSD-3-clause"

FULL_LINK = 'http://ports.ubuntu.com/ubuntu-ports/pool/universe/o/opencv/libopencv-video-dev_3.2.0+dfsg-4build2_arm64.deb'
DEB_NAME = 'libopencv-video-dev_3.2.0+dfsg-4build2_arm64.deb'

SRC_URI[md5sum] = "26ebdec7c53c49c9efbffa38276f3721"
