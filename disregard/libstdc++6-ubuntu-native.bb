inherit native deb-dl

LICENSE = "GPL-3.0-with-GCC-exception & GPLv3"

FULL_LINK = 'http://security.ubuntu.com/ubuntu/pool/main/g/gcc-8/libstdc++6_8.3.0-26ubuntu1~18.04_amd64.deb'
DEB_NAME = 'libstdc++6_8.3.0-26ubuntu1~18.04_amd64.deb'
SRC_URI[md5sum] = "0ef5f363a2d506ffa3132fb331c2a45a"
