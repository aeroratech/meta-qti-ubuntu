inherit native deb-dl

LICENSE = "EPL-1.0"

SRC_URI[md5sum] = "dd220854c0a3b0965bc547b83d28b3c7"

FULL_LINK = 'http://security.ubuntu.com/ubuntu/pool/main/g/gcc-7-cross/g++-7-aarch64-linux-gnu_7.5.0-3ubuntu1~18.04cross1_amd64.deb'
DEB_NAME = 'g++-7-aarch64-linux-gnu_7.5.0-3ubuntu1~18.04cross1_amd64.deb'
