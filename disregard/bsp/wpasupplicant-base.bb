
LICENSE = "BSD-3-Clause"

FULL_LINK = 'http://ports.ubuntu.com/ubuntu-ports/pool/main/w/wpa/wpasupplicant_2.6-15ubuntu2_arm64.deb'
DEB_NAME = 'wpasupplicant_2.6-15ubuntu2_arm64.deb'

SRC_URI[md5sum] = "4f13e2ec9f18a56d2b1ad96b32466615"
