
LICENSE = "LGPL-2.0+"

FULL_LINK = 'http://ports.ubuntu.com/ubuntu-ports/pool/main/libs/libseccomp/seccomp_2.3.1-2.1ubuntu4_arm64.deb'
DEB_NAME = 'seccomp_2.3.1-2.1ubuntu4_arm64.deb'

SRC_URI[md5sum] = "0c62960badd2fc6dde7a38944233c87e"
