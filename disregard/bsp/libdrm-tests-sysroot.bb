LICENSE = "MIT"

FULL_LINK = 'http://ports.ubuntu.com/ubuntu-ports/pool/main/libd/libdrm/libdrm-tests_2.4.101-2~18.04.1_arm64.deb'

DEB_NAME = 'libdrm-tests_2.4.101-2~18.04.1_arm64.deb'

SRC_URI[md5sum] = "5b9da357ced50ba582f1648ee973897f"
