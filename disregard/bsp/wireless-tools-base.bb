
LICENSE = "GPL-2.0 & LGPL-2.1+"

FULL_LINK = 'http://ports.ubuntu.com/ubuntu-ports/pool/main/w/wireless-tools/wireless-tools_30~pre9-12ubuntu1_arm64.deb'
DEB_NAME = 'wireless-tools_30~pre9-12ubuntu1_arm64.deb'

SRC_URI[md5sum] = "be9be4e26bfa0fd88438524500eb990b"
