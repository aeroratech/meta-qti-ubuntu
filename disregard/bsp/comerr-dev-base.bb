LICENSE = "GPL-2.0 & LGPL-2.0 & BSD-3-Clause & MIT"

FULL_LINK = 'http://ports.ubuntu.com/ubuntu-ports/pool/main/e/e2fsprogs/comerr-dev_2.1-1.44.1-1_arm64.deb'
DEB_NAME = 'comerr-dev_2.1-1.44.1-1_arm64.deb'

SRC_URI[md5sum] = "17ab8e6415a41e11a0ca5fb3231404f7"
