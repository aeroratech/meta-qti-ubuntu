LICENSE = "GPL-2.0+"

FULL_LINK = 'http://ports.ubuntu.com/ubuntu-ports/pool/universe/s/slang2/slsh_2.3.1a-3ubuntu1_arm64.deb'
DEB_NAME = 'slsh_2.3.1a-3ubuntu1_arm64.deb'

SRC_URI[md5sum] = "96ad0c76ee5f37d937c5cac9968b709a"
