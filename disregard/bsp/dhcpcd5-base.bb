
LICENSE = "BSD-2-Clause"

FULL_LINK = 'http://ports.ubuntu.com/ubuntu-ports/pool/universe/d/dhcpcd5/dhcpcd5_6.11.5-0ubuntu1_arm64.deb'
DEB_NAME = 'dhcpcd5_6.11.5-0ubuntu1_arm64.deb'

SRC_URI[md5sum] = "25ab6916b4f512d25377ea7fd1ba0abd"
