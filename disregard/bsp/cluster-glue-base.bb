
LICENSE = "LGPL-2.0+ & BSD-3-Clause & PD & GPL-2.0+"

FULL_LINK = 'http://ports.ubuntu.com/ubuntu-ports/pool/main/c/cluster-glue/cluster-glue_1.0.12-7build1_arm64.deb'
DEB_NAME = 'cluster-glue_1.0.12-7build1_arm64.deb'

SRC_URI[md5sum] = "b26644147fa2df9478c39fd2defb113a"
