
LICENSE = "GPL-2.0 & GPL-2.0+ & BSD-3-Clause & LGPL-2.1+"

FULL_LINK = 'http://ports.ubuntu.com/ubuntu-ports/pool/main/a/apparmor/apparmor_2.12-4ubuntu5_arm64.deb'
DEB_NAME = 'apparmor_2.12-4ubuntu5_arm64.deb'

SRC_URI[md5sum] = "23a9ce401c9a15a5bf40ee5750a9bcfa"
