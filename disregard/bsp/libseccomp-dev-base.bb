
LICENSE = "LGPL-2.0+"

FULL_LINK = 'http://ports.ubuntu.com/ubuntu-ports/pool/main/libs/libseccomp/libseccomp-dev_2.3.1-2.1ubuntu4_arm64.deb'
DEB_NAME = 'libseccomp-dev_2.3.1-2.1ubuntu4_arm64.deb'

SRC_URI[md5sum] = "b25f346619c18a3c71a60cd10862a4de"
