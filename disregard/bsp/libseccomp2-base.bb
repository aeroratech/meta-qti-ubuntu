
LICENSE = "LGPL-2.0+"

FULL_LINK = 'http://ports.ubuntu.com/ubuntu-ports/pool/main/libs/libseccomp/libseccomp2_2.3.1-2.1ubuntu4_arm64.deb'
DEB_NAME = 'libseccomp2_2.3.1-2.1ubuntu4_arm64.deb'

SRC_URI[md5sum] = "3f97f86860edb068333314df5f8b66db"
