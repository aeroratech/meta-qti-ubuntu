
LICENSE = "GPL-1.0+"

FULL_LINK = 'http://ports.ubuntu.com/ubuntu-ports/pool/universe/m/makepatch/makepatch_2.03-1.1_all.deb'
DEB_NAME = 'makepatch_2.03-1.1_all.deb'

SRC_URI[md5sum] = "80a70cc404c4cf9c4da320439becbd1b"
