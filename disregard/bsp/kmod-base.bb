
LICENSE = "GPL-2.0+ & LGPL-2.1+"

FULL_LINK = 'http://ports.ubuntu.com/ubuntu-ports/pool/main/k/kmod/kmod_24-1ubuntu3_arm64.deb'
DEB_NAME = 'kmod_24-1ubuntu3_arm64.deb'

SRC_URI[md5sum] = "ea35c10bb795e322ae298dc2aeb5399b"
