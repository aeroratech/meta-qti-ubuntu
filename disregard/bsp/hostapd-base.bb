
LICENSE = "BSD-3-Clause & PD & ISC"

FULL_LINK = 'http://ports.ubuntu.com/ubuntu-ports/pool/universe/w/wpa/hostapd_2.6-15ubuntu2_arm64.deb'
DEB_NAME = 'hostapd_2.6-15ubuntu2_arm64.deb'

SRC_URI[md5sum] = "a096ddf057a0f52577aed05bfcc86e7a"
