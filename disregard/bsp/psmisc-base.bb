
LICENSE = "GPL-2.0+"

FULL_LINK = 'http://ports.ubuntu.com/ubuntu-ports/pool/main/p/psmisc/psmisc_23.1-1_arm64.deb'
DEB_NAME = 'psmisc_23.1-1_arm64.deb'

SRC_URI[md5sum] = "64ee06fa96432897eb95af6bec4f41e6"
