
LICENSE = "BSD-3-Clause & BSD-4-Clause"

FULL_LINK = 'http://ports.ubuntu.com/ubuntu-ports/ pool/main/t/tftp-hpa/tftpd-hpa_5.2+20150808-1ubuntu3_arm64.deb'
DEB_NAME = 'tftpd-hpa_5.2+20150808-1ubuntu3_arm64.deb'

SRC_URI[md5sum] = "775901db30153814f3f90ac9a463afce"
