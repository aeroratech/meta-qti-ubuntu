LICENSE = "GPL-2.0"

FULL_LINK = 'http://ports.ubuntu.com/ubuntu-ports/pool/main/l/linux/linux-tools-common_4.15.0-112.113_all.deb'
DEB_NAME = 'linux-tools-common_4.15.0-112.113_all.deb'

SRC_URI[md5sum] = "429366efa2ef87b9f0458fc0999a6ee1"
