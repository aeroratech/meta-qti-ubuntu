
LICENSE = "GPL-2.0+"

FULL_LINK = 'http://ports.ubuntu.com/ubuntu-ports/pool/main/n/net-tools/net-tools_1.60+git20161116.90da8a0-1ubuntu1_arm64.deb'
DEB_NAME = 'net-tools_1.60+git20161116.90da8a0-1ubuntu1_arm64.deb'

SRC_URI[md5sum] = "f2bc530916c699cf6d8094fb4b9eb40b"
