
LICENSE = "LGPL-2.1+ & LGPL-2.0+ & GPL-2.0+"

FULL_LINK = 'http://ports.ubuntu.com/ubuntu-ports/pool/main/p/procps/procps_3.3.12-3ubuntu1_arm64.deb'
DEB_NAME = 'procps_3.3.12-3ubuntu1_arm64.deb'

SRC_URI[md5sum] = "a19040acfb4155118814118c94f1a652"
