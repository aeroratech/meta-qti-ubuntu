
LICENSE = "GPL-2.0 | GPL-3.0"

FULL_LINK = 'http://ports.ubuntu.com/ubuntu-ports/pool/universe/d/dnsmasq/dnsmasq_2.79-1_all.deb'
DEB_NAME = 'dnsmasq_2.79-1_all.deb'

SRC_URI[md5sum] = "614d544554f708475fce380f19d1b534"
