
LICENSE = "BSD-3-clause & BSD-2-clause & Powell-BSD-style & ISC & MIT"

FULL_LINK = 'http://ports.ubuntu.com/ubuntu-ports/pool/main/o/openssh/openssh-server_7.6p1-4_arm64.deb'
DEB_NAME = 'openssh-server_7.6p1-4_arm64.deb'

SRC_URI[md5sum] = "f3c00a9cc285b90dedc0ec67894559d8"
