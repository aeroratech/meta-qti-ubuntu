
LICENSE = "LGPL-2.0+"

FULL_LINK = 'http://ports.ubuntu.com/ubuntu-ports/pool/universe/g/gst-rtsp-server1.0/libgstrtspserver-1.0-0_1.14.0-1_arm64.deb'
DEB_NAME = 'libgstrtspserver-1.0-0_1.14.0-1_arm64.deb'

SRC_URI[md5sum] = "95a0fa948d6e238c6202e2f8084564bf"
