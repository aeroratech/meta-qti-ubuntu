
LICENSE = "GPL-3.0"

FULL_LINK = 'http://ports.ubuntu.com/ubuntu-ports/pool/main//w/wget/wget_1.19.4-1ubuntu2_arm64.deb'
DEB_NAME = 'wget_1.19.4-1ubuntu2_arm64.deb'

SRC_URI[md5sum] = "58384fecf6077b1f5f3c28c4aeff562f"
