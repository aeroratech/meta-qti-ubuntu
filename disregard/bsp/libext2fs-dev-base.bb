libext2fs-dev-base.bb
LICENSE = "GPL-2.0 & LGPL-2.0 & BSD-3-Clause & MIT"

FULL_LINK = 'http://ports.ubuntu.com/ubuntu-ports/pool/main/e/e2fsprogs/libext2fs-dev_1.44.1-1_arm64.deb'
DEB_NAME = 'libext2fs-dev_1.44.1-1_arm64.deb'

SRC_URI[md5sum] = "b600aa618c537acdb5a10abe191800b3"
