
LICENSE = "BSD-3-Clause & BSD-4-Clause"

FULL_LINK = 'http://ports.ubuntu.com/ubuntu-ports/pool/main/t/tftp-hpa/tftp-hpa_5.2+20150808-1ubuntu3_arm64.deb'
DEB_NAME = 'tftp-hpa_5.2+20150808-1ubuntu3_arm64.deb'

SRC_URI[md5sum] = "b68e18b287b7a1f38a3cf142e522b0f7"
