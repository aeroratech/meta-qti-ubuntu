
LICENSE = "ISC"

FULL_LINK = 'http://ports.ubuntu.com/ubuntu-ports/pool/main/i/iw/wpa/iw_4.14-0.1_arm64.deb'
DEB_NAME = 'iw_4.14-0.1_arm64.deb'

SRC_URI[md5sum] = "f46b09db7872a41cadde9415a5b4a2a5"
