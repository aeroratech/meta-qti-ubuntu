
LICENSE = "GPL-3.0"

FULL_LINK = 'http://ports.ubuntu.com/ubuntu-ports/pool/main/i/inetutils/inetutils-ping_1.9.4-3_arm64.deb'
DEB_NAME = 'inetutils-ping_1.9.4-3_arm64.deb'

SRC_URI[md5sum] = "0f23c027f9f1a47ce88e67217a4418ae"
