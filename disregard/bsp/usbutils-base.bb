
LICENSE = "GPL-2.0+"

FULL_LINK = 'http://ports.ubuntu.com/ubuntu-ports/pool/main/u/usbutils/usbutils_007-4build1_arm64.deb'
DEB_NAME = 'usbutils_007-4build1_arm64.deb'

SRC_URI[md5sum] = "dd75e825f40d73c7748cecd9613c08e2"
