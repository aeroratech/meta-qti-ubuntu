LICENSE = "Apache-2.0 & BSD-2-clause"

FULL_LINK = 'http://ports.ubuntu.com/ubuntu-ports/pool/universe/f/fscrypt/fscrypt_0.2.2-0ubuntu2_arm64.deb'
DEB_NAME = 'fscrypt_0.2.2-0ubuntu2_arm64.deb'

SRC_URI[md5sum] = "e417299076fe2bb04d3fdc77dfcaabab"
