
LICENSE = "BSD-3-Clause"

FULL_LINK = 'http://ports.ubuntu.com/ubuntu-ports/pool/universe/libu/libuvc/libuvc-dev_0.0.6-1_arm64.deb'
DEB_NAME = 'libuvc-dev_0.0.6-1_arm64.deb'

SRC_URI[md5sum] = "e87a0d4c5a7a987c28dc23cfa8fad05d"
