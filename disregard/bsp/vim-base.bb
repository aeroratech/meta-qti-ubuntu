
LICENSE = "vim"

FULL_LINK = 'http://ports.ubuntu.com/ubuntu-ports/pool/main/v/vim/vim_8.0.1453-1ubuntu1_arm64.deb'
DEB_NAME = 'vim_8.0.1453-1ubuntu1_arm64.deb'

SRC_URI[md5sum] = "61de2fc79f8f5be7bd3d459590bd2d0b"
