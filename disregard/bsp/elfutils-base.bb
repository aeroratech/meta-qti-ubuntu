LICENSE = "(GPL-2.0+ | LGPL-3.0+) & GPL-3.0+"

FULL_LINK = 'http://ports.ubuntu.com/ubuntu-ports/pool/main/e/elfutils/elfutils_0.170-0.4_arm64.deb'
DEB_NAME = 'elfutils_0.170-0.4_arm64.deb'

SRC_URI[md5sum] = "54e0806c627d943e495db2a85bdcd7a9"
