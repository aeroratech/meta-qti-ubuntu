
LICENSE = "GPL-3.0-with-GCC-exception & LGPL-2.1+ & LGPL-2.0+ & GPL-3.0+ & BSD-3-Clause"

FULL_LINK = 'http://ports.ubuntu.com/ubuntu-ports/pool/main/g/gdb/gdb_8.1-0ubuntu3_arm64.deb'
DEB_NAME = 'gdb_8.1-0ubuntu3_arm64.deb'

SRC_URI[md5sum] = "b780d5408d529cbe749b1a0f4388bac5"
