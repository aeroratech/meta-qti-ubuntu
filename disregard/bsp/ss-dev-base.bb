LICENSE = "GPL-2.0 & LGPL-2.0 & BSD-3-Clause & MIT"

FULL_LINK = 'http://ports.ubuntu.com/ubuntu-ports/pool/main/e/e2fsprogs/ss-dev_2.0-1.44.1-1_arm64.deb'
DEB_NAME = 'ss-dev_2.0-1.44.1-1_arm64.deb'

SRC_URI[md5sum] = "f87d7f40db78193327d4551c81d84f2d"
