
LICENSE = "BSD-3-Clause"

FULL_LINK = 'http://ports.ubuntu.com/ubuntu-ports/pool/universe/libu/libuvc/libuvc0_0.0.6-1_arm64.deb'
DEB_NAME = 'libuvc0_0.0.6-1_arm64.deb'

SRC_URI[md5sum] = "a77b4a47401fc56f02f1798f0c4f7805"
