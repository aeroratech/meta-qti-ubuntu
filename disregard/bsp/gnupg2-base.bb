
LICENSE = "GPL-3.0+ & LGPL-3.0+"

FULL_LINK = 'http://ports.ubuntu.com/ubuntu-ports/pool/universe/g/gnupg2/gnupg2_2.2.4-1ubuntu1.2_all.deb'
DEB_NAME = 'gnupg2_2.2.4-1ubuntu1.2_all.deb'

SRC_URI[md5sum] = "33911df4508ae8224d392c3994e1b3f5"
