inherit native deb-dl

LICENSE = "EPL-1.0"

FULL_LINK = 'http://security.ubuntu.com/ubuntu/pool/main/g/gcc-7-cross/gcc-7-aarch64-linux-gnu_7.5.0-3ubuntu1~18.04cross1_amd64.deb'
DEB_NAME = 'gcc-7-aarch64-linux-gnu_7.5.0-3ubuntu1~18.04cross1_amd64.deb'
SRC_URI[md5sum] = "a3fc9da38c9c5678014d614bdd7f0b11"
