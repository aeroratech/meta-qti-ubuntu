inherit native deb-dl

LICENSE = "LGPL-2.1+"

FULL_LINK = 'http://security.ubuntu.com/ubuntu/pool/main/m/mpclib3/libmpc3_1.1.0-1_amd64.deb'
DEB_NAME = 'libmpc3_1.1.0-1_amd64.deb'
SRC_URI[md5sum] = "904f40b9d70151d42df9b826986a24d8"
