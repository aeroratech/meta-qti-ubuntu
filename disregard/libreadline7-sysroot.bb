inherit native deb-dl

LICENSE = "GPL-3.0+"

FULL_LINK = 'http://security.ubuntu.com/ubuntu/pool/main/r/readline/libreadline7_7.0-3_amd64.deb'
DEB_NAME = 'libreadline7_7.0-3_amd64.deb'
SRC_URI[md5sum] = "178a174af25cb10d25743e0b46ac34bf"
