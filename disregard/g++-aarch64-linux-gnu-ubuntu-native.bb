inherit native deb-dl

LICENSE = "GPL-2.0+ & BSD-4-Clause"

SRC_URI[md5sum] = "389c92761e5e3d568645ecfc6e175104"

FULL_LINK = 'http://security.ubuntu.com/ubuntu/pool/main/g/gcc-defaults/g++-aarch64-linux-gnu_7.4.0-1ubuntu2.3_amd64.deb'
DEB_NAME = 'g++-aarch64-linux-gnu_7.4.0-1ubuntu2.3_amd64.deb'
