inherit native deb-dl

LICENSE = "LGPL-2.1 & GPL-2.0"

FULL_LINK = 'http://security.ubuntu.com/ubuntu/pool/main/g/glibc/libc6_2.27-3ubuntu1_amd64.deb'
DEB_NAME = 'libc6_2.27-3ubuntu1_amd64.deb'

SRC_URI[md5sum] = "4dbd1d7f5828ca977ed0fad6781f0b8d"
