
LICENSE = "Apache-2.0"

FULL_LINK = 'http://packages.ros.org/ros2/ubuntu/pool/main/r/ros-dashing-desktop/ros-dashing-desktop_0.7.3-1bionic.20200512.144036_arm64.deb'
DEB_NAME = 'ros-dashing-desktop_0.7.3-1bionic.20200512.144036_arm64.deb'

SRC_URI[md5sum] = "d8207cebd59654df6cfb643db5467f7c"
