LICENSE = "Apache-2.0"

FULL_LINK = 'http://packages.ros.org/ros2/ubuntu/pool/main/r/ros-dashing-ros-base/ros-dashing-ros-base_0.7.4-1bionic.20201125.120754_arm64.deb'
DEB_NAME = 'ros-dashing-ros-base_0.7.4-1bionic.20201125.120754_arm64.deb'

SRC_URI[md5sum] = "ef3657a5c6b43b5d5651e3052907388d"
