DEPENDS_remove = "rtsp-alg"
