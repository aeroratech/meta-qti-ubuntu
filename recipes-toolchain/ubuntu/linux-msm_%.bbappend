SRC_URI += " file://virtualization.cfg file://virtualization_robomaker.cfg "
