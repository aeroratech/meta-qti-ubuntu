inherit upkg_base
LICENSE = "EPL-1.0 & GPL-2.0"
LICENSE_linux-libc-dev-arm64-cross = "EPL-1.0 & GPL-2.0"

SRC_URI = "http://ports.ubuntu.com/ubuntu-ports/pool/main/c/cross-toolchain-base/linux-libc-dev-arm64-cross_5.4.0-21.25cross1_all.deb;name=linux-libc-dev-arm64-cross"

SRC_URI[linux-libc-dev-arm64-cross.md5sum] = "b47be11ecae7e512243fe2413ce0a6a9"