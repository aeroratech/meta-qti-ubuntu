# config update-alternatives for weston
require update-alternatives/weston_3.0.0.inc

