TOOLCHAIN_HOST_TASK_remove += "nativesdk-python3-git nativesdk-git-perltools"
