# config update-alternatives for qti-ubuntu-udev
require update-alternatives/qti-ubuntu-udev.inc
