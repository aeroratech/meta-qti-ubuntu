# config update-alternatives for tinycompress
require update-alternatives/tinycompress.inc

