# config update-alternatives for cairo
require update-alternatives/cairo.inc

