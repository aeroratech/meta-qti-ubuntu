# config update-alternatives for qti-ubuntu-login
require update-alternatives/qti-ubuntu-login.inc
