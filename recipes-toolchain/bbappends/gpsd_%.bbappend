RDEPENDS_gpsd-udev_remove = "udev"