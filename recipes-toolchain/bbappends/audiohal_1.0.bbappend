# add flag for ingore format warning error
CFLAGS_append_qrb5165 = " -Wno-format"
CFLAGS_append_qcs6490 = " -Wno-format"
