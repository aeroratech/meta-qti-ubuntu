# config update-alternatives for mesa
require update-alternatives/mesa.inc

