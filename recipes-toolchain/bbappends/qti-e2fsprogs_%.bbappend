# config update-alternatives for qti-e2fsprogs
require update-alternatives/qti-e2fsprogs.inc

