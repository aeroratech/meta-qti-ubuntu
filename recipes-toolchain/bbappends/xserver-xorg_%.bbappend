# config update-alternatives for xserver-xorg
require update-alternatives/xserver-xorg.inc

