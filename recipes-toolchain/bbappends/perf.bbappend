# config update-alternatives for perf
#require update-alternatives/perf.inc
do_package_qa[noexec] = "1"
