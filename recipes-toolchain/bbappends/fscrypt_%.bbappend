# config update-alternatives for fscrypt
require update-alternatives/fscrypt.inc

