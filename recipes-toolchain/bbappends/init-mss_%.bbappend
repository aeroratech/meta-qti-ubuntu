EXTRA_OECONFIG_remove_qrb5165 = "--enable-modem"
EXTRA_OECONFIG_remove_qcs6490 = "--enable-modem"
