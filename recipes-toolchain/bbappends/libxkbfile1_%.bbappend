PKG_libxkbfile1-dbg = "qti-libxkbfile1-dbg"