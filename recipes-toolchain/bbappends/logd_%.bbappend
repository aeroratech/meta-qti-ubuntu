# config update-alternatives for logd
require  update-alternatives/logd.inc
do_package_qa[noexec] = "1"
