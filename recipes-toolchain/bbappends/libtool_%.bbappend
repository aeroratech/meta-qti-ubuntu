PACKAGES_remove = "libltdl ${PN}-dbg"
