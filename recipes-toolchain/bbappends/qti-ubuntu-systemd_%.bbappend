# config update-alternatives for qti-ubuntu-systemd
require update-alternatives/qti-ubuntu-systemd.inc

