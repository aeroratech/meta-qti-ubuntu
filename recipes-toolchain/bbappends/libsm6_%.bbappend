PKG_libsm6-dbg = "qti-libsm6-dbg"