CORE_IMAGE_EXTRA_INSTALL_remove += "packagegroup-qti-core-prop \"
