PACKAGECONFIG_remove = "pcre"

