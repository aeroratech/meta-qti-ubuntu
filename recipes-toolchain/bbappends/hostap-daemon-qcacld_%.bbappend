# config update-alternatives for hostap-daemon-qcacld
require update-alternatives/hostap-daemon-qcacld.inc

