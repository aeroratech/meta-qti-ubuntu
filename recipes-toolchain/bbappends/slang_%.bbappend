# config update-alternatives for slang
require update-alternatives/slang.inc

