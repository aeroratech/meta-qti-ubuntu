# config update-alternatives for wlan-conf
require update-alternatives/wlan-conf.inc

