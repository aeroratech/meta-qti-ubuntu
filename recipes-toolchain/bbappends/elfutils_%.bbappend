# config update-alternatives for elfutils
#require update-alternatives/elfutils.inc

