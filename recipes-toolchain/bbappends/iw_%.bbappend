# config update-alternatives for iw
require update-alternatives/iw.inc

