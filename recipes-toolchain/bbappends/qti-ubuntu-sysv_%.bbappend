# config update-alternatives for qti-ubuntu-sysv
require update-alternatives/qti-ubuntu-sysv.inc
