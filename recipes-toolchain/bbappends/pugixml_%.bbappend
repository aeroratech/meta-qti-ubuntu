# config update-alternatives for pugixml
require  update-alternatives/pugixml.inc