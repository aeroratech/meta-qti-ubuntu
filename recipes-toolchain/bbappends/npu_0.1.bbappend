OECMAKE_C_COMPILER_aarch64 = "/usr/bin/${TARGET_ARCH}-linux-gnu-gcc"
OECMAKE_CXX_COMPILER_aarch64 = "/usr/bin/${TARGET_ARCH}-linux-gnu-g++"
