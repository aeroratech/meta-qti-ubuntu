# config update-alternatives for perf
require  update-alternatives/perf.inc