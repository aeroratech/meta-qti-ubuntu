RDEPENDS_${PN}_remove = "bt-ext"
