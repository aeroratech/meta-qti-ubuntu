RDEPENDS_python3-unixadmin += "libtirpc"
RDEPENDS_python3-curses += "curses"
do_package_qa[noexec] = "1"

