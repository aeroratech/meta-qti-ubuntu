# config update-alternatives for liblog
require  update-alternatives/liblog.inc