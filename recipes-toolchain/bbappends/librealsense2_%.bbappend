#enable yocto ccache
inherit ccache
