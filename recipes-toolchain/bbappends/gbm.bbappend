# config update-alternatives for gbm
require update-alternatives/gbm.inc
do_package_qa[noexec] = "1"
