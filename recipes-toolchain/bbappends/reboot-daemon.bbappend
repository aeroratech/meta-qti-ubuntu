CFLAGS:qcs6490 += " -DUBBASE "
