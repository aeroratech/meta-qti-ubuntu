PKG_libice6-dbg = "qti-libice6-dbg"