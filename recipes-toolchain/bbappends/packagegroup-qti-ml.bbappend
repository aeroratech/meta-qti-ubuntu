RDEPENDS_packagegroup-qti-ml_remove = "libgomp"
RDEPENDS_packagegroup-qti-ml-tflite_append = "libfmq"
