# config update-alternatives for weston
require  update-alternatives/weston.inc