FILESEXTRAPATHS_append := "${THISDIR}:${THISDIR}/opkg-utils:"

SRC_URI += " \
    file://0001-change-update-alternatives-for-ubuntu.patch \
"
