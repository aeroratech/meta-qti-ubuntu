PKG_libfontenc1-dbg = "qti-libfontenc1-dbg"