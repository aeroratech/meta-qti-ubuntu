PKG_libxxf86vm1-dbg = "qti-libxxf86vm1-dbg"