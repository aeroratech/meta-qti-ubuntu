OECMAKE_FIND_ROOT_PATH_MODE_PROGRAM = "BOTH"
do_package_qa[noexec] = "1"
