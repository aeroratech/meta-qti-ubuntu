OECMAKE_FIND_ROOT_PATH_MODE_PROGRAM_class-target_qrb5165 = "BOTH"
do_package_qa[noexec] = "1"
