OECMAKE_FIND_ROOT_PATH_MODE_PROGRAM_class-target_qrb5165 = "BOTH"
CODEC2_ENCODE_qrb5165 := "TRUE"
